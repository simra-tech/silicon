** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/g1_bgr.sch
**.subckt g1_bgr vdd vss r4 vref iptat pbias pcasc vbe dvbe
*.iopin vdd
*.iopin vss
*.ipin r4
*.opin vref
*.opin iptat
*.opin pbias
*.opin pcasc
*.opin vbe
*.opin dvbe
XMPS det pbias vdd bgr586_pmir
XRDET1 n_12 det vss bgr586_rdetu
XRDET2 n_12 n_25 vss bgr586_rdetu
XRDET3 n_13 n_25 vss bgr586_rdetu
XRDET4 n_13 n_24 vss bgr586_rdetu
XRDET5 n_14 n_24 vss bgr586_rdetu
XRDET6 n_14 n_26 vss bgr586_rdetu
XRDET7 n_15 n_26 vss bgr586_rdetu
XRDET8 n_15 n_27 vss bgr586_rdetu
XRDET9 n_16 n_27 vss bgr586_rdetu
XRDET10 n_16 n_21 vss bgr586_rdetu
XRDET11 n_17 n_21 vss bgr586_rdetu
XRDET12 n_17 n_22 vss bgr586_rdetu
XRDET13 n_18 n_22 vss bgr586_rdetu
XRDET14 n_18 n_23 vss bgr586_rdetu
XRDET15 vss n_23 vss bgr586_rdetu
XM27 kick det vdd vdd sg13_hv_pmos l=0.5u w=2u as=0.68p ad=0.68p ps=4.68u pd=4.68u rfmode=0
XM31 kick det vss vss sg13_hv_nmos l=0.6u w=1u as=0.34p ad=0.34p ps=2.68u pd=2.68u rfmode=0
XM30 pbias kick vss vss sg13_hv_nmos l=4u w=1u as=0.34p ad=0.34p ps=2.68u pd=2.68u rfmode=0
XMP5[23] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[22] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[21] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[20] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[19] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[18] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[17] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[16] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[15] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[14] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[13] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[12] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[11] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[10] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[9] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[8] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[7] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[6] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[5] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[4] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[3] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[2] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[1] vb2 d5 pbias pcasc vdd bgr586_pleg
XMP5[0] vb2 d5 pbias pcasc vdd bgr586_pleg
XRX1[23] n_6 vb2 vss bgr586_rxu
XRX1[22] n_6 vb2 vss bgr586_rxu
XRX1[21] n_6 vb2 vss bgr586_rxu
XRX1[20] n_6 vb2 vss bgr586_rxu
XRX1[19] n_6 vb2 vss bgr586_rxu
XRX1[18] n_6 vb2 vss bgr586_rxu
XRX1[17] n_6 vb2 vss bgr586_rxu
XRX1[16] n_6 vb2 vss bgr586_rxu
XRX1[15] n_6 vb2 vss bgr586_rxu
XRX1[14] n_6 vb2 vss bgr586_rxu
XRX1[13] n_6 vb2 vss bgr586_rxu
XRX1[12] n_6 vb2 vss bgr586_rxu
XRX1[11] n_6 vb2 vss bgr586_rxu
XRX1[10] n_6 vb2 vss bgr586_rxu
XRX1[9] n_6 vb2 vss bgr586_rxu
XRX1[8] n_6 vb2 vss bgr586_rxu
XRX1[7] n_6 vb2 vss bgr586_rxu
XRX1[6] n_6 vb2 vss bgr586_rxu
XRX1[5] n_6 vb2 vss bgr586_rxu
XRX1[4] n_6 vb2 vss bgr586_rxu
XRX1[3] n_6 vb2 vss bgr586_rxu
XRX1[2] n_6 vb2 vss bgr586_rxu
XRX1[1] n_6 vb2 vss bgr586_rxu
XRX1[0] n_6 vb2 vss bgr586_rxu
XRX2[23] n_6 n_19 vss bgr586_rxu
XRX2[22] n_6 n_19 vss bgr586_rxu
XRX2[21] n_6 n_19 vss bgr586_rxu
XRX2[20] n_6 n_19 vss bgr586_rxu
XRX2[19] n_6 n_19 vss bgr586_rxu
XRX2[18] n_6 n_19 vss bgr586_rxu
XRX2[17] n_6 n_19 vss bgr586_rxu
XRX2[16] n_6 n_19 vss bgr586_rxu
XRX2[15] n_6 n_19 vss bgr586_rxu
XRX2[14] n_6 n_19 vss bgr586_rxu
XRX2[13] n_6 n_19 vss bgr586_rxu
XRX2[12] n_6 n_19 vss bgr586_rxu
XRX2[11] n_6 n_19 vss bgr586_rxu
XRX2[10] n_6 n_19 vss bgr586_rxu
XRX2[9] n_6 n_19 vss bgr586_rxu
XRX2[8] n_6 n_19 vss bgr586_rxu
XRX2[7] n_6 n_19 vss bgr586_rxu
XRX2[6] n_6 n_19 vss bgr586_rxu
XRX2[5] n_6 n_19 vss bgr586_rxu
XRX2[4] n_6 n_19 vss bgr586_rxu
XRX2[3] n_6 n_19 vss bgr586_rxu
XRX2[2] n_6 n_19 vss bgr586_rxu
XRX2[1] n_6 n_19 vss bgr586_rxu
XRX2[0] n_6 n_19 vss bgr586_rxu
XRX3[23] n_9 n_19 vss bgr586_rxu
XRX3[22] n_9 n_19 vss bgr586_rxu
XRX3[21] n_9 n_19 vss bgr586_rxu
XRX3[20] n_9 n_19 vss bgr586_rxu
XRX3[19] n_9 n_19 vss bgr586_rxu
XRX3[18] n_9 n_19 vss bgr586_rxu
XRX3[17] n_9 n_19 vss bgr586_rxu
XRX3[16] n_9 n_19 vss bgr586_rxu
XRX3[15] n_9 n_19 vss bgr586_rxu
XRX3[14] n_9 n_19 vss bgr586_rxu
XRX3[13] n_9 n_19 vss bgr586_rxu
XRX3[12] n_9 n_19 vss bgr586_rxu
XRX3[11] n_9 n_19 vss bgr586_rxu
XRX3[10] n_9 n_19 vss bgr586_rxu
XRX3[9] n_9 n_19 vss bgr586_rxu
XRX3[8] n_9 n_19 vss bgr586_rxu
XRX3[7] n_9 n_19 vss bgr586_rxu
XRX3[6] n_9 n_19 vss bgr586_rxu
XRX3[5] n_9 n_19 vss bgr586_rxu
XRX3[4] n_9 n_19 vss bgr586_rxu
XRX3[3] n_9 n_19 vss bgr586_rxu
XRX3[2] n_9 n_19 vss bgr586_rxu
XRX3[1] n_9 n_19 vss bgr586_rxu
XRX3[0] n_9 n_19 vss bgr586_rxu
XRX4[23] n_9 vd1 vss bgr586_rxu
XRX4[22] n_9 vd1 vss bgr586_rxu
XRX4[21] n_9 vd1 vss bgr586_rxu
XRX4[20] n_9 vd1 vss bgr586_rxu
XRX4[19] n_9 vd1 vss bgr586_rxu
XRX4[18] n_9 vd1 vss bgr586_rxu
XRX4[17] n_9 vd1 vss bgr586_rxu
XRX4[16] n_9 vd1 vss bgr586_rxu
XRX4[15] n_9 vd1 vss bgr586_rxu
XRX4[14] n_9 vd1 vss bgr586_rxu
XRX4[13] n_9 vd1 vss bgr586_rxu
XRX4[12] n_9 vd1 vss bgr586_rxu
XRX4[11] n_9 vd1 vss bgr586_rxu
XRX4[10] n_9 vd1 vss bgr586_rxu
XRX4[9] n_9 vd1 vss bgr586_rxu
XRX4[8] n_9 vd1 vss bgr586_rxu
XRX4[7] n_9 vd1 vss bgr586_rxu
XRX4[6] n_9 vd1 vss bgr586_rxu
XRX4[5] n_9 vd1 vss bgr586_rxu
XRX4[4] n_9 vd1 vss bgr586_rxu
XRX4[3] n_9 vd1 vss bgr586_rxu
XRX4[2] n_9 vd1 vss bgr586_rxu
XRX4[1] n_9 vd1 vss bgr586_rxu
XRX4[0] n_9 vd1 vss bgr586_rxu
XQD1[23] vd1 vd1 vd2 vss bgr586_hbt
XQD1[22] vd1 vd1 vd2 vss bgr586_hbt
XQD1[21] vd1 vd1 vd2 vss bgr586_hbt
XQD1[20] vd1 vd1 vd2 vss bgr586_hbt
XQD1[19] vd1 vd1 vd2 vss bgr586_hbt
XQD1[18] vd1 vd1 vd2 vss bgr586_hbt
XQD1[17] vd1 vd1 vd2 vss bgr586_hbt
XQD1[16] vd1 vd1 vd2 vss bgr586_hbt
XQD1[15] vd1 vd1 vd2 vss bgr586_hbt
XQD1[14] vd1 vd1 vd2 vss bgr586_hbt
XQD1[13] vd1 vd1 vd2 vss bgr586_hbt
XQD1[12] vd1 vd1 vd2 vss bgr586_hbt
XQD1[11] vd1 vd1 vd2 vss bgr586_hbt
XQD1[10] vd1 vd1 vd2 vss bgr586_hbt
XQD1[9] vd1 vd1 vd2 vss bgr586_hbt
XQD1[8] vd1 vd1 vd2 vss bgr586_hbt
XQD1[7] vd1 vd1 vd2 vss bgr586_hbt
XQD1[6] vd1 vd1 vd2 vss bgr586_hbt
XQD1[5] vd1 vd1 vd2 vss bgr586_hbt
XQD1[4] vd1 vd1 vd2 vss bgr586_hbt
XQD1[3] vd1 vd1 vd2 vss bgr586_hbt
XQD1[2] vd1 vd1 vd2 vss bgr586_hbt
XQD1[1] vd1 vd1 vd2 vss bgr586_hbt
XQD1[0] vd1 vd1 vd2 vss bgr586_hbt
XQD2[23] vd2 vd2 vss vss bgr586_hbt
XQD2[22] vd2 vd2 vss vss bgr586_hbt
XQD2[21] vd2 vd2 vss vss bgr586_hbt
XQD2[20] vd2 vd2 vss vss bgr586_hbt
XQD2[19] vd2 vd2 vss vss bgr586_hbt
XQD2[18] vd2 vd2 vss vss bgr586_hbt
XQD2[17] vd2 vd2 vss vss bgr586_hbt
XQD2[16] vd2 vd2 vss vss bgr586_hbt
XQD2[15] vd2 vd2 vss vss bgr586_hbt
XQD2[14] vd2 vd2 vss vss bgr586_hbt
XQD2[13] vd2 vd2 vss vss bgr586_hbt
XQD2[12] vd2 vd2 vss vss bgr586_hbt
XQD2[11] vd2 vd2 vss vss bgr586_hbt
XQD2[10] vd2 vd2 vss vss bgr586_hbt
XQD2[9] vd2 vd2 vss vss bgr586_hbt
XQD2[8] vd2 vd2 vss vss bgr586_hbt
XQD2[7] vd2 vd2 vss vss bgr586_hbt
XQD2[6] vd2 vd2 vss vss bgr586_hbt
XQD2[5] vd2 vd2 vss vss bgr586_hbt
XQD2[4] vd2 vd2 vss vss bgr586_hbt
XQD2[3] vd2 vd2 vss vss bgr586_hbt
XQD2[2] vd2 vd2 vss vss bgr586_hbt
XQD2[1] vd2 vd2 vss vss bgr586_hbt
XQD2[0] vd2 vd2 vss vss bgr586_hbt
XMP1[23] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[22] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[21] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[20] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[19] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[18] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[17] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[16] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[15] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[14] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[13] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[12] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[11] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[10] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[9] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[8] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[7] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[6] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[5] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[4] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[3] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[2] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[1] n1 d1 pbias pcasc vdd bgr586_pleg
XMP1[0] n1 d1 pbias pcasc vdd bgr586_pleg
XMNC1[23] n1 vbe vb2 vss bgr586_ncas
XMNC1[22] n1 vbe vb2 vss bgr586_ncas
XMNC1[21] n1 vbe vb2 vss bgr586_ncas
XMNC1[20] n1 vbe vb2 vss bgr586_ncas
XMNC1[19] n1 vbe vb2 vss bgr586_ncas
XMNC1[18] n1 vbe vb2 vss bgr586_ncas
XMNC1[17] n1 vbe vb2 vss bgr586_ncas
XMNC1[16] n1 vbe vb2 vss bgr586_ncas
XMNC1[15] n1 vbe vb2 vss bgr586_ncas
XMNC1[14] n1 vbe vb2 vss bgr586_ncas
XMNC1[13] n1 vbe vb2 vss bgr586_ncas
XMNC1[12] n1 vbe vb2 vss bgr586_ncas
XMNC1[11] n1 vbe vb2 vss bgr586_ncas
XMNC1[10] n1 vbe vb2 vss bgr586_ncas
XMNC1[9] n1 vbe vb2 vss bgr586_ncas
XMNC1[8] n1 vbe vb2 vss bgr586_ncas
XMNC1[7] n1 vbe vb2 vss bgr586_ncas
XMNC1[6] n1 vbe vb2 vss bgr586_ncas
XMNC1[5] n1 vbe vb2 vss bgr586_ncas
XMNC1[4] n1 vbe vb2 vss bgr586_ncas
XMNC1[3] n1 vbe vb2 vss bgr586_ncas
XMNC1[2] n1 vbe vb2 vss bgr586_ncas
XMNC1[1] n1 vbe vb2 vss bgr586_ncas
XMNC1[0] n1 vbe vb2 vss bgr586_ncas
XQ1[23] vbe vbe vss vss bgr586_hbt
XQ1[22] vbe vbe vss vss bgr586_hbt
XQ1[21] vbe vbe vss vss bgr586_hbt
XQ1[20] vbe vbe vss vss bgr586_hbt
XQ1[19] vbe vbe vss vss bgr586_hbt
XQ1[18] vbe vbe vss vss bgr586_hbt
XQ1[17] vbe vbe vss vss bgr586_hbt
XQ1[16] vbe vbe vss vss bgr586_hbt
XQ1[15] vbe vbe vss vss bgr586_hbt
XQ1[14] vbe vbe vss vss bgr586_hbt
XQ1[13] vbe vbe vss vss bgr586_hbt
XQ1[12] vbe vbe vss vss bgr586_hbt
XQ1[11] vbe vbe vss vss bgr586_hbt
XQ1[10] vbe vbe vss vss bgr586_hbt
XQ1[9] vbe vbe vss vss bgr586_hbt
XQ1[8] vbe vbe vss vss bgr586_hbt
XQ1[7] vbe vbe vss vss bgr586_hbt
XQ1[6] vbe vbe vss vss bgr586_hbt
XQ1[5] vbe vbe vss vss bgr586_hbt
XQ1[4] vbe vbe vss vss bgr586_hbt
XQ1[3] vbe vbe vss vss bgr586_hbt
XQ1[2] vbe vbe vss vss bgr586_hbt
XQ1[1] vbe vbe vss vss bgr586_hbt
XQ1[0] vbe vbe vss vss bgr586_hbt
XQ1B[23] vbe b1b vss vss bgr586_hbt
XQ1B[22] vbe b1b vss vss bgr586_hbt
XQ1B[21] vbe b1b vss vss bgr586_hbt
XQ1B[20] vbe b1b vss vss bgr586_hbt
XQ1B[19] vbe b1b vss vss bgr586_hbt
XQ1B[18] vbe b1b vss vss bgr586_hbt
XQ1B[17] vbe b1b vss vss bgr586_hbt
XQ1B[16] vbe b1b vss vss bgr586_hbt
XQ1B[15] vbe b1b vss vss bgr586_hbt
XQ1B[14] vbe b1b vss vss bgr586_hbt
XQ1B[13] vbe b1b vss vss bgr586_hbt
XQ1B[12] vbe b1b vss vss bgr586_hbt
XQ1B[11] vbe b1b vss vss bgr586_hbt
XQ1B[10] vbe b1b vss vss bgr586_hbt
XQ1B[9] vbe b1b vss vss bgr586_hbt
XQ1B[8] vbe b1b vss vss bgr586_hbt
XQ1B[7] vbe b1b vss vss bgr586_hbt
XQ1B[6] vbe b1b vss vss bgr586_hbt
XQ1B[5] vbe b1b vss vss bgr586_hbt
XQ1B[4] vbe b1b vss vss bgr586_hbt
XQ1B[3] vbe b1b vss vss bgr586_hbt
XQ1B[2] vbe b1b vss vss bgr586_hbt
XQ1B[1] vbe b1b vss vss bgr586_hbt
XQ1B[0] vbe b1b vss vss bgr586_hbt
XMP2[23] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[22] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[21] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[20] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[19] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[18] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[17] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[16] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[15] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[14] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[13] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[12] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[11] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[10] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[9] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[8] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[7] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[6] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[5] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[4] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[3] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[2] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[1] pbias d2 pbias pcasc vdd bgr586_pleg
XMP2[0] pbias d2 pbias pcasc vdd bgr586_pleg
XRB1[23] n_4 pbias vss bgr586_rbu
XRB1[22] n_4 pbias vss bgr586_rbu
XRB1[21] n_4 pbias vss bgr586_rbu
XRB1[20] n_4 pbias vss bgr586_rbu
XRB1[19] n_4 pbias vss bgr586_rbu
XRB1[18] n_4 pbias vss bgr586_rbu
XRB1[17] n_4 pbias vss bgr586_rbu
XRB1[16] n_4 pbias vss bgr586_rbu
XRB1[15] n_4 pbias vss bgr586_rbu
XRB1[14] n_4 pbias vss bgr586_rbu
XRB1[13] n_4 pbias vss bgr586_rbu
XRB1[12] n_4 pbias vss bgr586_rbu
XRB1[11] n_4 pbias vss bgr586_rbu
XRB1[10] n_4 pbias vss bgr586_rbu
XRB1[9] n_4 pbias vss bgr586_rbu
XRB1[8] n_4 pbias vss bgr586_rbu
XRB1[7] n_4 pbias vss bgr586_rbu
XRB1[6] n_4 pbias vss bgr586_rbu
XRB1[5] n_4 pbias vss bgr586_rbu
XRB1[4] n_4 pbias vss bgr586_rbu
XRB1[3] n_4 pbias vss bgr586_rbu
XRB1[2] n_4 pbias vss bgr586_rbu
XRB1[1] n_4 pbias vss bgr586_rbu
XRB1[0] n_4 pbias vss bgr586_rbu
XRB2[23] n_4 n_30 vss bgr586_rbu
XRB2[22] n_4 n_30 vss bgr586_rbu
XRB2[21] n_4 n_30 vss bgr586_rbu
XRB2[20] n_4 n_30 vss bgr586_rbu
XRB2[19] n_4 n_30 vss bgr586_rbu
XRB2[18] n_4 n_30 vss bgr586_rbu
XRB2[17] n_4 n_30 vss bgr586_rbu
XRB2[16] n_4 n_30 vss bgr586_rbu
XRB2[15] n_4 n_30 vss bgr586_rbu
XRB2[14] n_4 n_30 vss bgr586_rbu
XRB2[13] n_4 n_30 vss bgr586_rbu
XRB2[12] n_4 n_30 vss bgr586_rbu
XRB2[11] n_4 n_30 vss bgr586_rbu
XRB2[10] n_4 n_30 vss bgr586_rbu
XRB2[9] n_4 n_30 vss bgr586_rbu
XRB2[8] n_4 n_30 vss bgr586_rbu
XRB2[7] n_4 n_30 vss bgr586_rbu
XRB2[6] n_4 n_30 vss bgr586_rbu
XRB2[5] n_4 n_30 vss bgr586_rbu
XRB2[4] n_4 n_30 vss bgr586_rbu
XRB2[3] n_4 n_30 vss bgr586_rbu
XRB2[2] n_4 n_30 vss bgr586_rbu
XRB2[1] n_4 n_30 vss bgr586_rbu
XRB2[0] n_4 n_30 vss bgr586_rbu
XRB3[23] n_5 n_30 vss bgr586_rbu
XRB3[22] n_5 n_30 vss bgr586_rbu
XRB3[21] n_5 n_30 vss bgr586_rbu
XRB3[20] n_5 n_30 vss bgr586_rbu
XRB3[19] n_5 n_30 vss bgr586_rbu
XRB3[18] n_5 n_30 vss bgr586_rbu
XRB3[17] n_5 n_30 vss bgr586_rbu
XRB3[16] n_5 n_30 vss bgr586_rbu
XRB3[15] n_5 n_30 vss bgr586_rbu
XRB3[14] n_5 n_30 vss bgr586_rbu
XRB3[13] n_5 n_30 vss bgr586_rbu
XRB3[12] n_5 n_30 vss bgr586_rbu
XRB3[11] n_5 n_30 vss bgr586_rbu
XRB3[10] n_5 n_30 vss bgr586_rbu
XRB3[9] n_5 n_30 vss bgr586_rbu
XRB3[8] n_5 n_30 vss bgr586_rbu
XRB3[7] n_5 n_30 vss bgr586_rbu
XRB3[6] n_5 n_30 vss bgr586_rbu
XRB3[5] n_5 n_30 vss bgr586_rbu
XRB3[4] n_5 n_30 vss bgr586_rbu
XRB3[3] n_5 n_30 vss bgr586_rbu
XRB3[2] n_5 n_30 vss bgr586_rbu
XRB3[1] n_5 n_30 vss bgr586_rbu
XRB3[0] n_5 n_30 vss bgr586_rbu
XRB4[23] n_5 n_31 vss bgr586_rbu
XRB4[22] n_5 n_31 vss bgr586_rbu
XRB4[21] n_5 n_31 vss bgr586_rbu
XRB4[20] n_5 n_31 vss bgr586_rbu
XRB4[19] n_5 n_31 vss bgr586_rbu
XRB4[18] n_5 n_31 vss bgr586_rbu
XRB4[17] n_5 n_31 vss bgr586_rbu
XRB4[16] n_5 n_31 vss bgr586_rbu
XRB4[15] n_5 n_31 vss bgr586_rbu
XRB4[14] n_5 n_31 vss bgr586_rbu
XRB4[13] n_5 n_31 vss bgr586_rbu
XRB4[12] n_5 n_31 vss bgr586_rbu
XRB4[11] n_5 n_31 vss bgr586_rbu
XRB4[10] n_5 n_31 vss bgr586_rbu
XRB4[9] n_5 n_31 vss bgr586_rbu
XRB4[8] n_5 n_31 vss bgr586_rbu
XRB4[7] n_5 n_31 vss bgr586_rbu
XRB4[6] n_5 n_31 vss bgr586_rbu
XRB4[5] n_5 n_31 vss bgr586_rbu
XRB4[4] n_5 n_31 vss bgr586_rbu
XRB4[3] n_5 n_31 vss bgr586_rbu
XRB4[2] n_5 n_31 vss bgr586_rbu
XRB4[1] n_5 n_31 vss bgr586_rbu
XRB4[0] n_5 n_31 vss bgr586_rbu
XRB5[23] n_3 n_31 vss bgr586_rbu
XRB5[22] n_3 n_31 vss bgr586_rbu
XRB5[21] n_3 n_31 vss bgr586_rbu
XRB5[20] n_3 n_31 vss bgr586_rbu
XRB5[19] n_3 n_31 vss bgr586_rbu
XRB5[18] n_3 n_31 vss bgr586_rbu
XRB5[17] n_3 n_31 vss bgr586_rbu
XRB5[16] n_3 n_31 vss bgr586_rbu
XRB5[15] n_3 n_31 vss bgr586_rbu
XRB5[14] n_3 n_31 vss bgr586_rbu
XRB5[13] n_3 n_31 vss bgr586_rbu
XRB5[12] n_3 n_31 vss bgr586_rbu
XRB5[11] n_3 n_31 vss bgr586_rbu
XRB5[10] n_3 n_31 vss bgr586_rbu
XRB5[9] n_3 n_31 vss bgr586_rbu
XRB5[8] n_3 n_31 vss bgr586_rbu
XRB5[7] n_3 n_31 vss bgr586_rbu
XRB5[6] n_3 n_31 vss bgr586_rbu
XRB5[5] n_3 n_31 vss bgr586_rbu
XRB5[4] n_3 n_31 vss bgr586_rbu
XRB5[3] n_3 n_31 vss bgr586_rbu
XRB5[2] n_3 n_31 vss bgr586_rbu
XRB5[1] n_3 n_31 vss bgr586_rbu
XRB5[0] n_3 n_31 vss bgr586_rbu
XRB6[23] n_3 n_33 vss bgr586_rbu
XRB6[22] n_3 n_33 vss bgr586_rbu
XRB6[21] n_3 n_33 vss bgr586_rbu
XRB6[20] n_3 n_33 vss bgr586_rbu
XRB6[19] n_3 n_33 vss bgr586_rbu
XRB6[18] n_3 n_33 vss bgr586_rbu
XRB6[17] n_3 n_33 vss bgr586_rbu
XRB6[16] n_3 n_33 vss bgr586_rbu
XRB6[15] n_3 n_33 vss bgr586_rbu
XRB6[14] n_3 n_33 vss bgr586_rbu
XRB6[13] n_3 n_33 vss bgr586_rbu
XRB6[12] n_3 n_33 vss bgr586_rbu
XRB6[11] n_3 n_33 vss bgr586_rbu
XRB6[10] n_3 n_33 vss bgr586_rbu
XRB6[9] n_3 n_33 vss bgr586_rbu
XRB6[8] n_3 n_33 vss bgr586_rbu
XRB6[7] n_3 n_33 vss bgr586_rbu
XRB6[6] n_3 n_33 vss bgr586_rbu
XRB6[5] n_3 n_33 vss bgr586_rbu
XRB6[4] n_3 n_33 vss bgr586_rbu
XRB6[3] n_3 n_33 vss bgr586_rbu
XRB6[2] n_3 n_33 vss bgr586_rbu
XRB6[1] n_3 n_33 vss bgr586_rbu
XRB6[0] n_3 n_33 vss bgr586_rbu
XRB7[23] n_10 n_33 vss bgr586_rbu
XRB7[22] n_10 n_33 vss bgr586_rbu
XRB7[21] n_10 n_33 vss bgr586_rbu
XRB7[20] n_10 n_33 vss bgr586_rbu
XRB7[19] n_10 n_33 vss bgr586_rbu
XRB7[18] n_10 n_33 vss bgr586_rbu
XRB7[17] n_10 n_33 vss bgr586_rbu
XRB7[16] n_10 n_33 vss bgr586_rbu
XRB7[15] n_10 n_33 vss bgr586_rbu
XRB7[14] n_10 n_33 vss bgr586_rbu
XRB7[13] n_10 n_33 vss bgr586_rbu
XRB7[12] n_10 n_33 vss bgr586_rbu
XRB7[11] n_10 n_33 vss bgr586_rbu
XRB7[10] n_10 n_33 vss bgr586_rbu
XRB7[9] n_10 n_33 vss bgr586_rbu
XRB7[8] n_10 n_33 vss bgr586_rbu
XRB7[7] n_10 n_33 vss bgr586_rbu
XRB7[6] n_10 n_33 vss bgr586_rbu
XRB7[5] n_10 n_33 vss bgr586_rbu
XRB7[4] n_10 n_33 vss bgr586_rbu
XRB7[3] n_10 n_33 vss bgr586_rbu
XRB7[2] n_10 n_33 vss bgr586_rbu
XRB7[1] n_10 n_33 vss bgr586_rbu
XRB7[0] n_10 n_33 vss bgr586_rbu
XRB8[23] n_10 n_34 vss bgr586_rbu
XRB8[22] n_10 n_34 vss bgr586_rbu
XRB8[21] n_10 n_34 vss bgr586_rbu
XRB8[20] n_10 n_34 vss bgr586_rbu
XRB8[19] n_10 n_34 vss bgr586_rbu
XRB8[18] n_10 n_34 vss bgr586_rbu
XRB8[17] n_10 n_34 vss bgr586_rbu
XRB8[16] n_10 n_34 vss bgr586_rbu
XRB8[15] n_10 n_34 vss bgr586_rbu
XRB8[14] n_10 n_34 vss bgr586_rbu
XRB8[13] n_10 n_34 vss bgr586_rbu
XRB8[12] n_10 n_34 vss bgr586_rbu
XRB8[11] n_10 n_34 vss bgr586_rbu
XRB8[10] n_10 n_34 vss bgr586_rbu
XRB8[9] n_10 n_34 vss bgr586_rbu
XRB8[8] n_10 n_34 vss bgr586_rbu
XRB8[7] n_10 n_34 vss bgr586_rbu
XRB8[6] n_10 n_34 vss bgr586_rbu
XRB8[5] n_10 n_34 vss bgr586_rbu
XRB8[4] n_10 n_34 vss bgr586_rbu
XRB8[3] n_10 n_34 vss bgr586_rbu
XRB8[2] n_10 n_34 vss bgr586_rbu
XRB8[1] n_10 n_34 vss bgr586_rbu
XRB8[0] n_10 n_34 vss bgr586_rbu
XRB9[23] n_11 n_34 vss bgr586_rbu
XRB9[22] n_11 n_34 vss bgr586_rbu
XRB9[21] n_11 n_34 vss bgr586_rbu
XRB9[20] n_11 n_34 vss bgr586_rbu
XRB9[19] n_11 n_34 vss bgr586_rbu
XRB9[18] n_11 n_34 vss bgr586_rbu
XRB9[17] n_11 n_34 vss bgr586_rbu
XRB9[16] n_11 n_34 vss bgr586_rbu
XRB9[15] n_11 n_34 vss bgr586_rbu
XRB9[14] n_11 n_34 vss bgr586_rbu
XRB9[13] n_11 n_34 vss bgr586_rbu
XRB9[12] n_11 n_34 vss bgr586_rbu
XRB9[11] n_11 n_34 vss bgr586_rbu
XRB9[10] n_11 n_34 vss bgr586_rbu
XRB9[9] n_11 n_34 vss bgr586_rbu
XRB9[8] n_11 n_34 vss bgr586_rbu
XRB9[7] n_11 n_34 vss bgr586_rbu
XRB9[6] n_11 n_34 vss bgr586_rbu
XRB9[5] n_11 n_34 vss bgr586_rbu
XRB9[4] n_11 n_34 vss bgr586_rbu
XRB9[3] n_11 n_34 vss bgr586_rbu
XRB9[2] n_11 n_34 vss bgr586_rbu
XRB9[1] n_11 n_34 vss bgr586_rbu
XRB9[0] n_11 n_34 vss bgr586_rbu
XRB10[23] n_11 pcasc vss bgr586_rbu
XRB10[22] n_11 pcasc vss bgr586_rbu
XRB10[21] n_11 pcasc vss bgr586_rbu
XRB10[20] n_11 pcasc vss bgr586_rbu
XRB10[19] n_11 pcasc vss bgr586_rbu
XRB10[18] n_11 pcasc vss bgr586_rbu
XRB10[17] n_11 pcasc vss bgr586_rbu
XRB10[16] n_11 pcasc vss bgr586_rbu
XRB10[15] n_11 pcasc vss bgr586_rbu
XRB10[14] n_11 pcasc vss bgr586_rbu
XRB10[13] n_11 pcasc vss bgr586_rbu
XRB10[12] n_11 pcasc vss bgr586_rbu
XRB10[11] n_11 pcasc vss bgr586_rbu
XRB10[10] n_11 pcasc vss bgr586_rbu
XRB10[9] n_11 pcasc vss bgr586_rbu
XRB10[8] n_11 pcasc vss bgr586_rbu
XRB10[7] n_11 pcasc vss bgr586_rbu
XRB10[6] n_11 pcasc vss bgr586_rbu
XRB10[5] n_11 pcasc vss bgr586_rbu
XRB10[4] n_11 pcasc vss bgr586_rbu
XRB10[3] n_11 pcasc vss bgr586_rbu
XRB10[2] n_11 pcasc vss bgr586_rbu
XRB10[1] n_11 pcasc vss bgr586_rbu
XRB10[0] n_11 pcasc vss bgr586_rbu
XMNC2[23] c2 pcasc vb2 vss bgr586_ncas
XMNC2[22] c2 pcasc vb2 vss bgr586_ncas
XMNC2[21] c2 pcasc vb2 vss bgr586_ncas
XMNC2[20] c2 pcasc vb2 vss bgr586_ncas
XMNC2[19] c2 pcasc vb2 vss bgr586_ncas
XMNC2[18] c2 pcasc vb2 vss bgr586_ncas
XMNC2[17] c2 pcasc vb2 vss bgr586_ncas
XMNC2[16] c2 pcasc vb2 vss bgr586_ncas
XMNC2[15] c2 pcasc vb2 vss bgr586_ncas
XMNC2[14] c2 pcasc vb2 vss bgr586_ncas
XMNC2[13] c2 pcasc vb2 vss bgr586_ncas
XMNC2[12] c2 pcasc vb2 vss bgr586_ncas
XMNC2[11] c2 pcasc vb2 vss bgr586_ncas
XMNC2[10] c2 pcasc vb2 vss bgr586_ncas
XMNC2[9] c2 pcasc vb2 vss bgr586_ncas
XMNC2[8] c2 pcasc vb2 vss bgr586_ncas
XMNC2[7] c2 pcasc vb2 vss bgr586_ncas
XMNC2[6] c2 pcasc vb2 vss bgr586_ncas
XMNC2[5] c2 pcasc vb2 vss bgr586_ncas
XMNC2[4] c2 pcasc vb2 vss bgr586_ncas
XMNC2[3] c2 pcasc vb2 vss bgr586_ncas
XMNC2[2] c2 pcasc vb2 vss bgr586_ncas
XMNC2[1] c2 pcasc vb2 vss bgr586_ncas
XMNC2[0] c2 pcasc vb2 vss bgr586_ncas
XQ2[191] c2 vbe dvbe vss bgr586_hbt
XQ2[190] c2 vbe dvbe vss bgr586_hbt
XQ2[189] c2 vbe dvbe vss bgr586_hbt
XQ2[188] c2 vbe dvbe vss bgr586_hbt
XQ2[187] c2 vbe dvbe vss bgr586_hbt
XQ2[186] c2 vbe dvbe vss bgr586_hbt
XQ2[185] c2 vbe dvbe vss bgr586_hbt
XQ2[184] c2 vbe dvbe vss bgr586_hbt
XQ2[183] c2 vbe dvbe vss bgr586_hbt
XQ2[182] c2 vbe dvbe vss bgr586_hbt
XQ2[181] c2 vbe dvbe vss bgr586_hbt
XQ2[180] c2 vbe dvbe vss bgr586_hbt
XQ2[179] c2 vbe dvbe vss bgr586_hbt
XQ2[178] c2 vbe dvbe vss bgr586_hbt
XQ2[177] c2 vbe dvbe vss bgr586_hbt
XQ2[176] c2 vbe dvbe vss bgr586_hbt
XQ2[175] c2 vbe dvbe vss bgr586_hbt
XQ2[174] c2 vbe dvbe vss bgr586_hbt
XQ2[173] c2 vbe dvbe vss bgr586_hbt
XQ2[172] c2 vbe dvbe vss bgr586_hbt
XQ2[171] c2 vbe dvbe vss bgr586_hbt
XQ2[170] c2 vbe dvbe vss bgr586_hbt
XQ2[169] c2 vbe dvbe vss bgr586_hbt
XQ2[168] c2 vbe dvbe vss bgr586_hbt
XQ2[167] c2 vbe dvbe vss bgr586_hbt
XQ2[166] c2 vbe dvbe vss bgr586_hbt
XQ2[165] c2 vbe dvbe vss bgr586_hbt
XQ2[164] c2 vbe dvbe vss bgr586_hbt
XQ2[163] c2 vbe dvbe vss bgr586_hbt
XQ2[162] c2 vbe dvbe vss bgr586_hbt
XQ2[161] c2 vbe dvbe vss bgr586_hbt
XQ2[160] c2 vbe dvbe vss bgr586_hbt
XQ2[159] c2 vbe dvbe vss bgr586_hbt
XQ2[158] c2 vbe dvbe vss bgr586_hbt
XQ2[157] c2 vbe dvbe vss bgr586_hbt
XQ2[156] c2 vbe dvbe vss bgr586_hbt
XQ2[155] c2 vbe dvbe vss bgr586_hbt
XQ2[154] c2 vbe dvbe vss bgr586_hbt
XQ2[153] c2 vbe dvbe vss bgr586_hbt
XQ2[152] c2 vbe dvbe vss bgr586_hbt
XQ2[151] c2 vbe dvbe vss bgr586_hbt
XQ2[150] c2 vbe dvbe vss bgr586_hbt
XQ2[149] c2 vbe dvbe vss bgr586_hbt
XQ2[148] c2 vbe dvbe vss bgr586_hbt
XQ2[147] c2 vbe dvbe vss bgr586_hbt
XQ2[146] c2 vbe dvbe vss bgr586_hbt
XQ2[145] c2 vbe dvbe vss bgr586_hbt
XQ2[144] c2 vbe dvbe vss bgr586_hbt
XQ2[143] c2 vbe dvbe vss bgr586_hbt
XQ2[142] c2 vbe dvbe vss bgr586_hbt
XQ2[141] c2 vbe dvbe vss bgr586_hbt
XQ2[140] c2 vbe dvbe vss bgr586_hbt
XQ2[139] c2 vbe dvbe vss bgr586_hbt
XQ2[138] c2 vbe dvbe vss bgr586_hbt
XQ2[137] c2 vbe dvbe vss bgr586_hbt
XQ2[136] c2 vbe dvbe vss bgr586_hbt
XQ2[135] c2 vbe dvbe vss bgr586_hbt
XQ2[134] c2 vbe dvbe vss bgr586_hbt
XQ2[133] c2 vbe dvbe vss bgr586_hbt
XQ2[132] c2 vbe dvbe vss bgr586_hbt
XQ2[131] c2 vbe dvbe vss bgr586_hbt
XQ2[130] c2 vbe dvbe vss bgr586_hbt
XQ2[129] c2 vbe dvbe vss bgr586_hbt
XQ2[128] c2 vbe dvbe vss bgr586_hbt
XQ2[127] c2 vbe dvbe vss bgr586_hbt
XQ2[126] c2 vbe dvbe vss bgr586_hbt
XQ2[125] c2 vbe dvbe vss bgr586_hbt
XQ2[124] c2 vbe dvbe vss bgr586_hbt
XQ2[123] c2 vbe dvbe vss bgr586_hbt
XQ2[122] c2 vbe dvbe vss bgr586_hbt
XQ2[121] c2 vbe dvbe vss bgr586_hbt
XQ2[120] c2 vbe dvbe vss bgr586_hbt
XQ2[119] c2 vbe dvbe vss bgr586_hbt
XQ2[118] c2 vbe dvbe vss bgr586_hbt
XQ2[117] c2 vbe dvbe vss bgr586_hbt
XQ2[116] c2 vbe dvbe vss bgr586_hbt
XQ2[115] c2 vbe dvbe vss bgr586_hbt
XQ2[114] c2 vbe dvbe vss bgr586_hbt
XQ2[113] c2 vbe dvbe vss bgr586_hbt
XQ2[112] c2 vbe dvbe vss bgr586_hbt
XQ2[111] c2 vbe dvbe vss bgr586_hbt
XQ2[110] c2 vbe dvbe vss bgr586_hbt
XQ2[109] c2 vbe dvbe vss bgr586_hbt
XQ2[108] c2 vbe dvbe vss bgr586_hbt
XQ2[107] c2 vbe dvbe vss bgr586_hbt
XQ2[106] c2 vbe dvbe vss bgr586_hbt
XQ2[105] c2 vbe dvbe vss bgr586_hbt
XQ2[104] c2 vbe dvbe vss bgr586_hbt
XQ2[103] c2 vbe dvbe vss bgr586_hbt
XQ2[102] c2 vbe dvbe vss bgr586_hbt
XQ2[101] c2 vbe dvbe vss bgr586_hbt
XQ2[100] c2 vbe dvbe vss bgr586_hbt
XQ2[99] c2 vbe dvbe vss bgr586_hbt
XQ2[98] c2 vbe dvbe vss bgr586_hbt
XQ2[97] c2 vbe dvbe vss bgr586_hbt
XQ2[96] c2 vbe dvbe vss bgr586_hbt
XQ2[95] c2 vbe dvbe vss bgr586_hbt
XQ2[94] c2 vbe dvbe vss bgr586_hbt
XQ2[93] c2 vbe dvbe vss bgr586_hbt
XQ2[92] c2 vbe dvbe vss bgr586_hbt
XQ2[91] c2 vbe dvbe vss bgr586_hbt
XQ2[90] c2 vbe dvbe vss bgr586_hbt
XQ2[89] c2 vbe dvbe vss bgr586_hbt
XQ2[88] c2 vbe dvbe vss bgr586_hbt
XQ2[87] c2 vbe dvbe vss bgr586_hbt
XQ2[86] c2 vbe dvbe vss bgr586_hbt
XQ2[85] c2 vbe dvbe vss bgr586_hbt
XQ2[84] c2 vbe dvbe vss bgr586_hbt
XQ2[83] c2 vbe dvbe vss bgr586_hbt
XQ2[82] c2 vbe dvbe vss bgr586_hbt
XQ2[81] c2 vbe dvbe vss bgr586_hbt
XQ2[80] c2 vbe dvbe vss bgr586_hbt
XQ2[79] c2 vbe dvbe vss bgr586_hbt
XQ2[78] c2 vbe dvbe vss bgr586_hbt
XQ2[77] c2 vbe dvbe vss bgr586_hbt
XQ2[76] c2 vbe dvbe vss bgr586_hbt
XQ2[75] c2 vbe dvbe vss bgr586_hbt
XQ2[74] c2 vbe dvbe vss bgr586_hbt
XQ2[73] c2 vbe dvbe vss bgr586_hbt
XQ2[72] c2 vbe dvbe vss bgr586_hbt
XQ2[71] c2 vbe dvbe vss bgr586_hbt
XQ2[70] c2 vbe dvbe vss bgr586_hbt
XQ2[69] c2 vbe dvbe vss bgr586_hbt
XQ2[68] c2 vbe dvbe vss bgr586_hbt
XQ2[67] c2 vbe dvbe vss bgr586_hbt
XQ2[66] c2 vbe dvbe vss bgr586_hbt
XQ2[65] c2 vbe dvbe vss bgr586_hbt
XQ2[64] c2 vbe dvbe vss bgr586_hbt
XQ2[63] c2 vbe dvbe vss bgr586_hbt
XQ2[62] c2 vbe dvbe vss bgr586_hbt
XQ2[61] c2 vbe dvbe vss bgr586_hbt
XQ2[60] c2 vbe dvbe vss bgr586_hbt
XQ2[59] c2 vbe dvbe vss bgr586_hbt
XQ2[58] c2 vbe dvbe vss bgr586_hbt
XQ2[57] c2 vbe dvbe vss bgr586_hbt
XQ2[56] c2 vbe dvbe vss bgr586_hbt
XQ2[55] c2 vbe dvbe vss bgr586_hbt
XQ2[54] c2 vbe dvbe vss bgr586_hbt
XQ2[53] c2 vbe dvbe vss bgr586_hbt
XQ2[52] c2 vbe dvbe vss bgr586_hbt
XQ2[51] c2 vbe dvbe vss bgr586_hbt
XQ2[50] c2 vbe dvbe vss bgr586_hbt
XQ2[49] c2 vbe dvbe vss bgr586_hbt
XQ2[48] c2 vbe dvbe vss bgr586_hbt
XQ2[47] c2 vbe dvbe vss bgr586_hbt
XQ2[46] c2 vbe dvbe vss bgr586_hbt
XQ2[45] c2 vbe dvbe vss bgr586_hbt
XQ2[44] c2 vbe dvbe vss bgr586_hbt
XQ2[43] c2 vbe dvbe vss bgr586_hbt
XQ2[42] c2 vbe dvbe vss bgr586_hbt
XQ2[41] c2 vbe dvbe vss bgr586_hbt
XQ2[40] c2 vbe dvbe vss bgr586_hbt
XQ2[39] c2 vbe dvbe vss bgr586_hbt
XQ2[38] c2 vbe dvbe vss bgr586_hbt
XQ2[37] c2 vbe dvbe vss bgr586_hbt
XQ2[36] c2 vbe dvbe vss bgr586_hbt
XQ2[35] c2 vbe dvbe vss bgr586_hbt
XQ2[34] c2 vbe dvbe vss bgr586_hbt
XQ2[33] c2 vbe dvbe vss bgr586_hbt
XQ2[32] c2 vbe dvbe vss bgr586_hbt
XQ2[31] c2 vbe dvbe vss bgr586_hbt
XQ2[30] c2 vbe dvbe vss bgr586_hbt
XQ2[29] c2 vbe dvbe vss bgr586_hbt
XQ2[28] c2 vbe dvbe vss bgr586_hbt
XQ2[27] c2 vbe dvbe vss bgr586_hbt
XQ2[26] c2 vbe dvbe vss bgr586_hbt
XQ2[25] c2 vbe dvbe vss bgr586_hbt
XQ2[24] c2 vbe dvbe vss bgr586_hbt
XQ2[23] c2 vbe dvbe vss bgr586_hbt
XQ2[22] c2 vbe dvbe vss bgr586_hbt
XQ2[21] c2 vbe dvbe vss bgr586_hbt
XQ2[20] c2 vbe dvbe vss bgr586_hbt
XQ2[19] c2 vbe dvbe vss bgr586_hbt
XQ2[18] c2 vbe dvbe vss bgr586_hbt
XQ2[17] c2 vbe dvbe vss bgr586_hbt
XQ2[16] c2 vbe dvbe vss bgr586_hbt
XQ2[15] c2 vbe dvbe vss bgr586_hbt
XQ2[14] c2 vbe dvbe vss bgr586_hbt
XQ2[13] c2 vbe dvbe vss bgr586_hbt
XQ2[12] c2 vbe dvbe vss bgr586_hbt
XQ2[11] c2 vbe dvbe vss bgr586_hbt
XQ2[10] c2 vbe dvbe vss bgr586_hbt
XQ2[9] c2 vbe dvbe vss bgr586_hbt
XQ2[8] c2 vbe dvbe vss bgr586_hbt
XQ2[7] c2 vbe dvbe vss bgr586_hbt
XQ2[6] c2 vbe dvbe vss bgr586_hbt
XQ2[5] c2 vbe dvbe vss bgr586_hbt
XQ2[4] c2 vbe dvbe vss bgr586_hbt
XQ2[3] c2 vbe dvbe vss bgr586_hbt
XQ2[2] c2 vbe dvbe vss bgr586_hbt
XQ2[1] c2 vbe dvbe vss bgr586_hbt
XQ2[0] c2 vbe dvbe vss bgr586_hbt
XR1[23] vss dvbe vss bgr586_r1u
XR1[22] vss dvbe vss bgr586_r1u
XR1[21] vss dvbe vss bgr586_r1u
XR1[20] vss dvbe vss bgr586_r1u
XR1[19] vss dvbe vss bgr586_r1u
XR1[18] vss dvbe vss bgr586_r1u
XR1[17] vss dvbe vss bgr586_r1u
XR1[16] vss dvbe vss bgr586_r1u
XR1[15] vss dvbe vss bgr586_r1u
XR1[14] vss dvbe vss bgr586_r1u
XR1[13] vss dvbe vss bgr586_r1u
XR1[12] vss dvbe vss bgr586_r1u
XR1[11] vss dvbe vss bgr586_r1u
XR1[10] vss dvbe vss bgr586_r1u
XR1[9] vss dvbe vss bgr586_r1u
XR1[8] vss dvbe vss bgr586_r1u
XR1[7] vss dvbe vss bgr586_r1u
XR1[6] vss dvbe vss bgr586_r1u
XR1[5] vss dvbe vss bgr586_r1u
XR1[4] vss dvbe vss bgr586_r1u
XR1[3] vss dvbe vss bgr586_r1u
XR1[2] vss dvbe vss bgr586_r1u
XR1[1] vss dvbe vss bgr586_r1u
XR1[0] vss dvbe vss bgr586_r1u
XMP3[3] vref d3 pbias pcasc vdd bgr586_pleg
XMP3[2] vref d3 pbias pcasc vdd bgr586_pleg
XMP3[1] vref d3 pbias pcasc vdd bgr586_pleg
XMP3[0] vref d3 pbias pcasc vdd bgr586_pleg
XR21[3] n_7 vref vss bgr586_r2u
XR21[2] n_7 vref vss bgr586_r2u
XR21[1] n_7 vref vss bgr586_r2u
XR21[0] n_7 vref vss bgr586_r2u
XR22[3] n_7 n_36 vss bgr586_r2u
XR22[2] n_7 n_36 vss bgr586_r2u
XR22[1] n_7 n_36 vss bgr586_r2u
XR22[0] n_7 n_36 vss bgr586_r2u
XR23[3] n_2 n_36 vss bgr586_r2u
XR23[2] n_2 n_36 vss bgr586_r2u
XR23[1] n_2 n_36 vss bgr586_r2u
XR23[0] n_2 n_36 vss bgr586_r2u
XR24[3] n_2 n_37 vss bgr586_r2u
XR24[2] n_2 n_37 vss bgr586_r2u
XR24[1] n_2 n_37 vss bgr586_r2u
XR24[0] n_2 n_37 vss bgr586_r2u
XR25[3] n_8 n_37 vss bgr586_r2u
XR25[2] n_8 n_37 vss bgr586_r2u
XR25[1] n_8 n_37 vss bgr586_r2u
XR25[0] n_8 n_37 vss bgr586_r2u
XR26[3] n_8 vbe3 vss bgr586_r2u
XR26[2] n_8 vbe3 vss bgr586_r2u
XR26[1] n_8 vbe3 vss bgr586_r2u
XR26[0] n_8 vbe3 vss bgr586_r2u
XQREF[3] vbe3 vbe3 vss vss bgr586_hbt
XQREF[2] vbe3 vbe3 vss vss bgr586_hbt
XQREF[1] vbe3 vbe3 vss vss bgr586_hbt
XQREF[0] vbe3 vbe3 vss vss bgr586_hbt
XMP4 iptat d4 pbias pcasc vdd bgr586_pleg
XM28 r4n r4 vdd vdd sg13_hv_pmos l=0.5u w=2u as=0.68p ad=0.68p ps=4.68u pd=4.68u rfmode=0
XM29 vbe r4 b1b vss sg13_hv_nmos l=0.5u w=2u as=0.68p ad=0.68p ps=4.68u pd=4.68u rfmode=0
XM32 r4n r4 vss vss sg13_hv_nmos l=0.5u w=1u as=0.34p ad=0.34p ps=2.68u pd=2.68u rfmode=0
XM33 b1b r4n vss vss sg13_hv_nmos l=0.6u w=1u as=0.34p ad=0.34p ps=2.68u pd=2.68u rfmode=0
XQDUM[8] vss vss vss vss bgr586_hbt
XQDUM[7] vss vss vss vss bgr586_hbt
XQDUM[6] vss vss vss vss bgr586_hbt
XQDUM[5] vss vss vss vss bgr586_hbt
XQDUM[4] vss vss vss vss bgr586_hbt
XQDUM[3] vss vss vss vss bgr586_hbt
XQDUM[2] vss vss vss vss bgr586_hbt
XQDUM[1] vss vss vss vss bgr586_hbt
XQDUM[0] vss vss vss vss bgr586_hbt
XCEXT c2 d1 d2 d3 d4 d5 n1 r4 b1b det r4n vb2 vbe vd1 vd2 vdd vss dvbe kick vbe3 vref iptat pbias
+ pcasc n_2 n_3 n_4 n_5 n_6 n_7 n_8 n_9 n_10 n_11 n_12 n_13 n_14 n_15 n_16 n_17 n_18 n_19 n_21 n_22 n_23
+ n_24 n_25 n_26 n_27 n_30 n_31 n_33 n_34 n_36 n_37 bgr586_cext
**.ends

* expanding   symbol:  bgr586_pmir.sym # of pins=3
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_pmir.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_pmir.sch
.subckt bgr586_pmir d g vdd
*.opin d
*.ipin g
*.iopin vdd
XMA d g vdd vdd sg13_hv_pmos l=4u w=5u as=1.7p ad=1.7p ps=10.68u pd=10.68u rfmode=0
XMB d g vdd vdd sg13_hv_pmos l=4u w=5u as=1.7p ad=1.7p ps=10.68u pd=10.68u rfmode=0
.ends


* expanding   symbol:  bgr586_rdetu.sym # of pins=3
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_rdetu.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_rdetu.sch
.subckt bgr586_rdetu p m bd
*.iopin p
*.iopin m
*.iopin bd
XR p m bd rhigh w=0.5u l=49u m=1 b=0
.ends


* expanding   symbol:  bgr586_pleg.sym # of pins=5
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_pleg.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_pleg.sch
.subckt bgr586_pleg out mid pbias pcasc vdd
*.opin out
*.iopin mid
*.ipin pbias
*.ipin pcasc
*.iopin vdd
XMA mid pbias vdd vdd sg13_hv_pmos l=4u w=5u as=1.7p ad=1.7p ps=10.68u pd=10.68u rfmode=0
XMB mid pbias vdd vdd sg13_hv_pmos l=4u w=5u as=1.7p ad=1.7p ps=10.68u pd=10.68u rfmode=0
XMC out pcasc mid mid sg13_hv_pmos l=4u w=10u as=3.4p ad=3.4p ps=20.68u pd=20.68u rfmode=0
.ends


* expanding   symbol:  bgr586_rxu.sym # of pins=3
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_rxu.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_rxu.sch
.subckt bgr586_rxu p m bd
*.iopin p
*.iopin m
*.iopin bd
XR p m bd rppd w=1u l=48u m=1 b=0
.ends


* expanding   symbol:  bgr586_hbt.sym # of pins=4
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_hbt.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_hbt.sch
.subckt bgr586_hbt c b e s
*.iopin c
*.ipin b
*.iopin e
*.iopin s
XQ c b e s npn13G2 we=0.07u le=0.9u m=1 Nx=1
.ends


* expanding   symbol:  bgr586_ncas.sym # of pins=4
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_ncas.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_ncas.sch
.subckt bgr586_ncas a b g vss
*.iopin a
*.iopin b
*.ipin g
*.iopin vss
XMA a g b vss sg13_hv_nmos l=1u w=10u as=3.4p ad=3.4p ps=20.68u pd=20.68u rfmode=0
XMB b g a vss sg13_hv_nmos l=1u w=10u as=3.4p ad=3.4p ps=20.68u pd=20.68u rfmode=0
.ends


* expanding   symbol:  bgr586_rbu.sym # of pins=3
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_rbu.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_rbu.sch
.subckt bgr586_rbu p m bd
*.iopin p
*.iopin m
*.iopin bd
XR p m bd rppd w=1u l=50u m=1 b=0
.ends


* expanding   symbol:  bgr586_r1u.sym # of pins=3
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_r1u.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_r1u.sch
.subckt bgr586_r1u p m bd
*.iopin p
*.iopin m
*.iopin bd
XR p m bd rppd w=1u l=51.5u m=1 b=0
.ends


* expanding   symbol:  bgr586_r2u.sym # of pins=3
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_r2u.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_r2u.sch
.subckt bgr586_r2u p m bd
*.iopin p
*.iopin m
*.iopin bd
XR p m bd rppd w=1u l=53.465u m=1 b=0
.ends


* expanding   symbol:  bgr586_cext.sym # of pins=55
** sym_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_cext.sym
** sch_path: designs/g1-guardian/blocks/g1_bgr/xschem/bgr586/bgr586_cext.sch
.subckt bgr586_cext c2 d1 d2 d3 d4 d5 n1 r4 b1b det r4n vb2 vbe vd1 vd2 vdd vss dvbe kick vbe3 vref
+ iptat pbias pcasc n_2 n_3 n_4 n_5 n_6 n_7 n_8 n_9 n_10 n_11 n_12 n_13 n_14 n_15 n_16 n_17 n_18 n_19 n_21
+ n_22 n_23 n_24 n_25 n_26 n_27 n_30 n_31 n_33 n_34 n_36 n_37
*.iopin c2
*.iopin d1
*.iopin d2
*.iopin d3
*.iopin d4
*.iopin d5
*.iopin n1
*.iopin r4
*.iopin b1b
*.iopin det
*.iopin r4n
*.iopin vb2
*.iopin vbe
*.iopin vd1
*.iopin vd2
*.iopin vdd
*.iopin vss
*.iopin dvbe
*.iopin kick
*.iopin vbe3
*.iopin vref
*.iopin iptat
*.iopin pbias
*.iopin pcasc
*.iopin n_2
*.iopin n_3
*.iopin n_4
*.iopin n_5
*.iopin n_6
*.iopin n_7
*.iopin n_8
*.iopin n_9
*.iopin n_10
*.iopin n_11
*.iopin n_12
*.iopin n_13
*.iopin n_14
*.iopin n_15
*.iopin n_16
*.iopin n_17
*.iopin n_18
*.iopin n_19
*.iopin n_21
*.iopin n_22
*.iopin n_23
*.iopin n_24
*.iopin n_25
*.iopin n_26
*.iopin n_27
*.iopin n_30
*.iopin n_31
*.iopin n_33
*.iopin n_34
*.iopin n_36
*.iopin n_37
Cext_1 n_10 n_11 15.5101e-18
Cext_2 n_10 n_3 19.0458e-18
Cext_3 n_10 vss 100.194e-18
Cext_4 n_10 vss 481.031e-18
Cext_5 n_11 n_12 2.09203e-18
Cext_6 n_11 n_3 0.524321e-18
Cext_7 n_11 vss 100.194e-18
Cext_8 n_11 vss 493.568e-18
Cext_9 n_12 n_13 14.2084e-18
Cext_10 n_12 vss 62.783e-18
Cext_11 n_12 vss 309.014e-18
Cext_12 n_13 n_14 14.2084e-18
Cext_13 n_13 vss 62.783e-18
Cext_14 n_13 vss 297.347e-18
Cext_15 n_14 n_15 14.2084e-18
Cext_16 n_14 vss 62.783e-18
Cext_17 n_14 vss 297.347e-18
Cext_18 n_15 n_16 14.2084e-18
Cext_19 n_15 vss 62.783e-18
Cext_20 n_15 vss 297.347e-18
Cext_21 n_16 n_17 14.2084e-18
Cext_22 n_16 vss 71.2957e-18
Cext_23 n_16 vss 295.974e-18
Cext_24 n_17 n_18 14.2084e-18
Cext_25 n_17 vss 63.3242e-18
Cext_26 n_17 vss 297.347e-18
Cext_27 n_18 vss 81.0158e-18
Cext_28 n_18 vss 297.347e-18
Cext_29 n_19 n_31 0.26116e-18
Cext_30 n_19 n_33 0.26116e-18
Cext_31 n_19 n_36 14.9703e-18
Cext_32 n_19 n_37 14.9703e-18
Cext_33 n_19 dvbe 159.131e-18
Cext_34 n_19 pbias 5.07141e-18
Cext_35 n_19 vb2 172.86e-18
Cext_36 n_19 vbe3 95.8794e-18
Cext_37 n_19 vd1 193.63e-18
Cext_38 n_19 vd2 410.357e-18
Cext_39 n_19 vref 95.1702e-18
Cext_40 n_19 vss 223.967e-18
Cext_41 n_19 vss 1.72175f
Cext_42 n_2 n_3 694.791e-18
Cext_43 n_2 n_6 0.524321e-18
Cext_44 n_2 n_7 19.0458e-18
Cext_45 n_2 n_8 19.0458e-18
Cext_46 n_2 n_9 0.524321e-18
Cext_47 n_2 vss 501.967e-18
Cext_48 n_2 vss 734.815e-18
Cext_49 n_21 n_22 14.2084e-18
Cext_50 n_21 n_27 14.2084e-18
Cext_51 n_21 b1b 0.735115e-18
Cext_52 n_21 vss 12.0025e-18
Cext_53 n_21 vss 331.598e-18
Cext_54 n_22 n_23 14.2084e-18
Cext_55 n_22 b1b 0.735115e-18
Cext_56 n_22 vss 12.0025e-18
Cext_57 n_22 vss 331.598e-18
Cext_58 n_23 b1b 0.735115e-18
Cext_59 n_23 vss 14.9704e-18
Cext_60 n_23 vss 341.848e-18
Cext_61 n_24 n_25 14.2084e-18
Cext_62 n_24 n_26 14.2084e-18
Cext_63 n_24 b1b 0.735115e-18
Cext_64 n_24 det 0.541131e-18
Cext_65 n_24 vss 12.0025e-18
Cext_66 n_24 vss 331.598e-18
Cext_67 n_25 b1b 0.735115e-18
Cext_68 n_25 det 18.2327e-18
Cext_69 n_25 vss 12.0025e-18
Cext_70 n_25 vss 331.598e-18
Cext_71 n_26 n_27 14.2084e-18
Cext_72 n_26 b1b 0.735115e-18
Cext_73 n_26 det 0.167332e-18
Cext_74 n_26 vss 12.0025e-18
Cext_75 n_26 vss 331.598e-18
Cext_76 n_27 b1b 0.735115e-18
Cext_77 n_27 vss 12.0025e-18
Cext_78 n_27 vss 331.598e-18
Cext_79 n_3 n_4 0.524321e-18
Cext_80 n_3 n_5 19.0458e-18
Cext_81 n_3 n_6 31.1754e-18
Cext_82 n_3 n_7 12.6539e-18
Cext_83 n_3 n_8 12.6539e-18
Cext_84 n_3 n_9 30.9049e-18
Cext_85 n_3 vss 903.669e-18
Cext_86 n_3 vss 1.48902f
Cext_87 n_30 n_31 15.5101e-18
Cext_88 n_30 dvbe 1.65454e-18
Cext_89 n_30 pbias 19.0458e-18
Cext_90 n_30 vb2 0.855051e-18
Cext_91 n_30 vss 24.3204e-18
Cext_92 n_30 vss 527.822e-18
Cext_93 n_31 dvbe 1.65454e-18
Cext_94 n_31 pbias 0.524321e-18
Cext_95 n_31 vb2 5.91722e-18
Cext_96 n_31 vss 24.3204e-18
Cext_97 n_31 vss 541.141e-18
Cext_98 n_33 n_34 15.5101e-18
Cext_99 n_33 b1b 0.120904e-18
Cext_100 n_33 pcasc 0.524321e-18
Cext_101 n_33 vbe3 2.26884e-18
Cext_102 n_33 vd1 5.91722e-18
Cext_103 n_33 vss 24.2823e-18
Cext_104 n_33 vss 541.141e-18
Cext_105 n_34 b1b 0.247176e-18
Cext_106 n_34 pcasc 19.0458e-18
Cext_107 n_34 vbe3 2.29766e-18
Cext_108 n_34 vd1 0.855051e-18
Cext_109 n_34 vss 24.3204e-18
Cext_110 n_34 vss 527.822e-18
Cext_111 n_36 n_37 4.91263e-18
Cext_112 n_36 dvbe 1.31773e-18
Cext_113 n_36 pbias 0.253448e-18
Cext_114 n_36 vref 19.777e-18
Cext_115 n_36 vss 103.246e-18
Cext_116 n_36 vss 490.2e-18
Cext_117 n_37 dvbe 5.91722e-18
Cext_118 n_37 pbias 0.253448e-18
Cext_119 n_37 vbe3 19.777e-18
Cext_120 n_37 vd2 0.820484e-18
Cext_121 n_37 vss 91.632e-18
Cext_122 n_37 vss 490.2e-18
Cext_123 n_4 n_5 15.5101e-18
Cext_124 n_4 vss 111.854e-18
Cext_125 n_4 vss 490.996e-18
Cext_126 n_5 vss 100.194e-18
Cext_127 n_5 vss 481.031e-18
Cext_128 n_6 n_7 15.5101e-18
Cext_129 n_6 vss 94.7854e-18
Cext_130 n_6 vss 481.031e-18
Cext_131 n_7 vss 95.5187e-18
Cext_132 n_7 vss 481.031e-18
Cext_133 n_8 n_9 15.5101e-18
Cext_134 n_8 vss 95.1057e-18
Cext_135 n_8 vss 481.031e-18
Cext_136 n_9 vss 99.5028e-18
Cext_137 n_9 vss 480.311e-18
Cext_138 b1b det 3.08988f
Cext_139 b1b kick 18.9647e-18
Cext_140 b1b pbias 847.105e-18
Cext_141 b1b pcasc 735.082e-18
Cext_142 b1b r4 332.534e-18
Cext_143 b1b r4n 197.625e-18
Cext_144 b1b vbe 741.197e-18
Cext_145 b1b vbe3 1.07019f
Cext_146 b1b vd1 42.3574e-18
Cext_147 b1b vd2 0.214735e-18
Cext_148 b1b vss 1.39679f
Cext_149 c2 det 1.09491e-18
Cext_150 c2 dvbe 14.8445f
Cext_151 c2 n1 1.78008f
Cext_152 c2 pbias 3.1973e-18
Cext_153 c2 pcasc 683.913e-18
Cext_154 c2 vb2 1.28399f
Cext_155 c2 vbe 407.234e-18
Cext_156 c2 vref 0.457024e-18
Cext_157 c2 vss 1.76096f
Cext_158 d1 d2 3.38132f
Cext_159 d1 d3 369.77e-18
Cext_160 d1 d4 105.35e-18
Cext_161 d1 d5 67.0643e-18
Cext_162 d1 det 66.6465e-18
Cext_163 d1 iptat 1.22759e-18
Cext_164 d1 kick 66.4272e-18
Cext_165 d1 n1 69.0247e-18
Cext_166 d1 pbias 5.54508f
Cext_167 d1 pcasc 539.684e-18
Cext_168 d1 r4 89.8574e-18
Cext_169 d1 r4n 66.3707e-18
Cext_170 d1 vb2 3.51936e-18
Cext_171 d1 vdd 478.72e-18
Cext_172 d1 vref 85.5231e-18
Cext_173 d1 vss 7.31884e-18
Cext_174 d2 d3 2.47943f
Cext_175 d2 d4 603.724e-18
Cext_176 d2 d5 62.4898e-18
Cext_177 d2 det 270.036e-18
Cext_178 d2 iptat 1.22759e-18
Cext_179 d2 kick 84.8402e-18
Cext_180 d2 n1 85.2692e-18
Cext_181 d2 pbias 1.59819f
Cext_182 d2 pcasc 541.399e-18
Cext_183 d2 r4 89.9071e-18
Cext_184 d2 r4n 66.4466e-18
Cext_185 d2 vb2 0.58192e-18
Cext_186 d2 vdd 478.512e-18
Cext_187 d2 vss 8.38671e-18
Cext_188 d3 d4 3.36401f
Cext_189 d3 d5 495.887e-18
Cext_190 d3 det 67.4106e-18
Cext_191 d3 iptat 1.22759e-18
Cext_192 d3 kick 66.5915e-18
Cext_193 d3 pbias 1.54168f
Cext_194 d3 pcasc 541.425e-18
Cext_195 d3 r4 89.9115e-18
Cext_196 d3 r4n 66.4676e-18
Cext_197 d3 vb2 86.7912e-18
Cext_198 d3 vdd 478.512e-18
Cext_199 d3 vref 69.0247e-18
Cext_200 d3 vss 1.8489e-18
Cext_201 d4 d5 5.71403f
Cext_202 d4 det 99.591e-18
Cext_203 d4 iptat 70.2523e-18
Cext_204 d4 kick 248.615e-18
Cext_205 d4 pbias 1.56219f
Cext_206 d4 pcasc 540.29e-18
Cext_207 d4 r4 90.2237e-18
Cext_208 d4 r4n 71.5847e-18
Cext_209 d4 vb2 0.238401e-18
Cext_210 d4 vdd 480.244e-18
Cext_211 d4 vss 13.0714e-18
Cext_212 d5 det 9.09587f
Cext_213 d5 iptat 1.22759e-18
Cext_214 d5 kick 86.0785e-18
Cext_215 d5 pbias 1.34059f
Cext_216 d5 pcasc 545.423e-18
Cext_217 d5 r4 241.428e-18
Cext_218 d5 r4n 170.512e-18
Cext_219 d5 vb2 69.4934e-18
Cext_220 d5 vdd 478.512e-18
Cext_221 d5 vss 9.92566e-18
Cext_222 det dvbe 1.47054e-18
Cext_223 det kick 10.5027f
Cext_224 det n1 2.03967e-18
Cext_225 det pbias 2.27172f
Cext_226 det pcasc 7.15985f
Cext_227 det r4 360.612e-18
Cext_228 det r4n 824.601e-18
Cext_229 det vb2 60.8768e-18
Cext_230 det vbe 32.2826e-18
Cext_231 det vbe3 34.4541e-18
Cext_232 det vdd 339.328e-18
Cext_233 det vss 783.982e-18
Cext_234 dvbe iptat 0.236884e-18
Cext_235 dvbe kick 0.311768e-18
Cext_236 dvbe n1 3.63074e-18
Cext_237 dvbe pbias 193.075e-18
Cext_238 dvbe pcasc 5.36919e-18
Cext_239 dvbe vb2 89.4959e-18
Cext_240 dvbe vbe 11.6494f
Cext_241 dvbe vbe3 15.8721e-18
Cext_242 dvbe vd1 0.145608e-18
Cext_243 dvbe vd2 156.801e-18
Cext_244 dvbe vref 4.6575f
Cext_245 dvbe vss 3.91955f
Cext_246 iptat n1 45.5207e-18
Cext_247 iptat pbias 6.1594e-18
Cext_248 iptat pcasc 975.203e-18
Cext_249 iptat vb2 6.11366f
Cext_250 iptat vbe 70.5206e-18
Cext_251 iptat vref 223.508e-18
Cext_252 iptat vss 289.493e-18
Cext_253 kick pbias 1.11756f
Cext_254 kick pcasc 12.9977e-18
Cext_255 kick r4 126.975e-18
Cext_256 kick r4n 7.98667f
Cext_257 kick vb2 3.0592e-18
Cext_258 kick vbe 0.356062e-18
Cext_259 kick vdd 152.428e-18
Cext_260 kick vss 519.69e-18
Cext_261 n1 pbias 6.39949e-18
Cext_262 n1 pcasc 4.83147f
Cext_263 n1 vb2 1.32414f
Cext_264 n1 vbe 1.91233f
Cext_265 n1 vref 6.41414e-18
Cext_266 n1 vss 116.638e-18
Cext_267 pbias pcasc 9.33416f
Cext_268 pbias r4 2.50831f
Cext_269 pbias r4n 732.455e-18
Cext_270 pbias vb2 1.54255f
Cext_271 pbias vbe 3.71289e-18
Cext_272 pbias vbe3 157.678e-18
Cext_273 pbias vd1 49.6104e-18
Cext_274 pbias vd2 147.156e-18
Cext_275 pbias vdd 3.85011f
Cext_276 pbias vref 213.907e-18
Cext_277 pbias vss 3.75278f
Cext_278 pcasc r4 2.77052e-18
Cext_279 pcasc r4n 2.04066e-18
Cext_280 pcasc vb2 3.71047f
Cext_281 pcasc vbe 953.297e-18
Cext_282 pcasc vbe3 313.659e-18
Cext_283 pcasc vref 2.31913f
Cext_284 pcasc vss 598.224e-18
Cext_285 r4 r4n 12.2762f
Cext_286 r4 vbe 285.464e-18
Cext_287 r4 vdd 83.346e-18
Cext_288 r4 vss 415.346e-18
Cext_289 r4n vbe 62.6373e-18
Cext_290 r4n vdd 158.562e-18
Cext_291 r4n vss 591.385e-18
Cext_292 vb2 vbe 1.27566f
Cext_293 vb2 vref 6.68835f
Cext_294 vb2 vss 708.188e-18
Cext_295 vbe vbe3 11.0316e-18
Cext_296 vbe vd1 10.5784e-18
Cext_297 vbe vd2 29.0277e-18
Cext_298 vbe vref 223.747e-18
Cext_299 vbe vss 5.2939f
Cext_300 vbe3 vd1 394.468e-18
Cext_301 vbe3 vd2 245.219e-18
Cext_302 vbe3 vss 1.39267f
Cext_303 vd1 vd2 2.03701f
Cext_304 vd1 vss 364.135e-18
Cext_305 vd2 vss 1.51724f
Cext_306 vref vss 480.6e-18
Cext_307 vss b1b 4.41403f
Cext_308 vss c2 4.95536f
Cext_309 vss d1 2.31262f
Cext_310 vss d2 2.22418f
Cext_311 vss d3 2.35423f
Cext_312 vss d4 2.28807f
Cext_313 vss d5 2.73371f
Cext_314 vss det 6.4979f
Cext_315 vss dvbe 6.69786f
Cext_316 vss iptat 1.94954f
Cext_317 vss kick 3.02926f
Cext_318 vss n1 2.16318f
Cext_319 vss pbias 45.0447f
Cext_320 vss pcasc 30.7628f
Cext_321 vss r4 4.25325f
Cext_322 vss r4n 2.48056f
Cext_323 vss vb2 11.6562f
Cext_324 vss vbe 8.8365f
Cext_325 vss vbe3 1.77779f
Cext_326 vss vd1 1.42461f
Cext_327 vss vd2 1.56685f
Cext_328 vss vdd 18.8574f
Cext_329 vss vref 2.41436f
.ends

.end
