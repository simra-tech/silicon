v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
E {}
B 4 40 -4600 2040 -4448 {fill=false}
T {bgr586_cext - 329 extraction capacitors of the candidate netlist (not design elements)} 52 -4590 0 0 0.55 0.55 {}
T {G1 guardian, chip of record g1_chip_top_1414_r2.gds 9049e87b (r2 2026-09-25; geometry XOR-identical to r1 629d303a); block map: g1_padring/reports/signoff-1414-20260924} 52 -4551 0 0 0.3 0.3 {}
T {On-chip variant: BGR586 = the chip BGR (cell __rz_port_text_031_g1_bgr_candidate); layout bank.gds e3ecfc62, LVS reference bank.cdl 7f8e6e8c} 52 -4527 0 0 0.3 0.3 {}
T {Netlist-equivalent to the Cext_* lines of sim/qualification/candidates/bgr_loop24_qref4_r253p465_hv06/bgr_loop24_qref4_r253p465_hv06.spice sha256 586ffb58} 52 -4503 0 0 0.3 0.3 {}
T {Drawn 2026-09-25 by the block generator; device sizes (w, l, ng, m) are on each symbol. Proof: review/schematics-readability-20260925} 52 -4479 0 0 0.25 0.25 {}
C {b586_cap.sym} 200 -2600 0 0 {name=Cext_1 value=15.5101e-18}
C {b586_cap.sym} 340 -2600 0 0 {name=Cext_2 value=19.0458e-18}
C {b586_cap.sym} 480 -2600 0 0 {name=Cext_3 value=100.194e-18}
C {b586_cap.sym} 620 -2600 0 0 {name=Cext_4 value=481.031e-18}
C {b586_cap.sym} 760 -2600 0 0 {name=Cext_5 value=2.09203e-18}
C {b586_cap.sym} 900 -2600 0 0 {name=Cext_6 value=0.524321e-18}
C {b586_cap.sym} 1040 -2600 0 0 {name=Cext_7 value=100.194e-18}
C {b586_cap.sym} 1180 -2600 0 0 {name=Cext_8 value=493.568e-18}
C {b586_cap.sym} 1320 -2600 0 0 {name=Cext_9 value=14.2084e-18}
C {b586_cap.sym} 1460 -2600 0 0 {name=Cext_10 value=62.783e-18}
C {b586_cap.sym} 1600 -2600 0 0 {name=Cext_11 value=309.014e-18}
C {b586_cap.sym} 1740 -2600 0 0 {name=Cext_12 value=14.2084e-18}
C {b586_cap.sym} 1880 -2600 0 0 {name=Cext_13 value=62.783e-18}
C {b586_cap.sym} 2020 -2600 0 0 {name=Cext_14 value=297.347e-18}
C {b586_cap.sym} 2160 -2600 0 0 {name=Cext_15 value=14.2084e-18}
C {b586_cap.sym} 2300 -2600 0 0 {name=Cext_16 value=62.783e-18}
C {b586_cap.sym} 2440 -2600 0 0 {name=Cext_17 value=297.347e-18}
C {b586_cap.sym} 2580 -2600 0 0 {name=Cext_18 value=14.2084e-18}
C {b586_cap.sym} 2720 -2600 0 0 {name=Cext_19 value=62.783e-18}
C {b586_cap.sym} 2860 -2600 0 0 {name=Cext_20 value=297.347e-18}
C {b586_cap.sym} 3000 -2600 0 0 {name=Cext_21 value=14.2084e-18}
C {b586_cap.sym} 3140 -2600 0 0 {name=Cext_22 value=71.2957e-18}
C {b586_cap.sym} 3280 -2600 0 0 {name=Cext_23 value=295.974e-18}
C {b586_cap.sym} 3420 -2600 0 0 {name=Cext_24 value=14.2084e-18}
C {b586_cap.sym} 3560 -2600 0 0 {name=Cext_25 value=63.3242e-18}
C {b586_cap.sym} 3700 -2600 0 0 {name=Cext_26 value=297.347e-18}
C {b586_cap.sym} 3840 -2600 0 0 {name=Cext_27 value=81.0158e-18}
C {b586_cap.sym} 3980 -2600 0 0 {name=Cext_28 value=297.347e-18}
C {b586_cap.sym} 4120 -2600 0 0 {name=Cext_29 value=0.26116e-18}
C {b586_cap.sym} 4260 -2600 0 0 {name=Cext_30 value=0.26116e-18}
C {b586_cap.sym} 200 -2440 0 0 {name=Cext_31 value=14.9703e-18}
C {b586_cap.sym} 340 -2440 0 0 {name=Cext_32 value=14.9703e-18}
C {b586_cap.sym} 480 -2440 0 0 {name=Cext_33 value=159.131e-18}
C {b586_cap.sym} 620 -2440 0 0 {name=Cext_34 value=5.07141e-18}
C {b586_cap.sym} 760 -2440 0 0 {name=Cext_35 value=172.86e-18}
C {b586_cap.sym} 900 -2440 0 0 {name=Cext_36 value=95.8794e-18}
C {b586_cap.sym} 1040 -2440 0 0 {name=Cext_37 value=193.63e-18}
C {b586_cap.sym} 1180 -2440 0 0 {name=Cext_38 value=410.357e-18}
C {b586_cap.sym} 1320 -2440 0 0 {name=Cext_39 value=95.1702e-18}
C {b586_cap.sym} 1460 -2440 0 0 {name=Cext_40 value=223.967e-18}
C {b586_cap.sym} 1600 -2440 0 0 {name=Cext_41 value=1.72175f}
C {b586_cap.sym} 1740 -2440 0 0 {name=Cext_42 value=694.791e-18}
C {b586_cap.sym} 1880 -2440 0 0 {name=Cext_43 value=0.524321e-18}
C {b586_cap.sym} 2020 -2440 0 0 {name=Cext_44 value=19.0458e-18}
C {b586_cap.sym} 2160 -2440 0 0 {name=Cext_45 value=19.0458e-18}
C {b586_cap.sym} 2300 -2440 0 0 {name=Cext_46 value=0.524321e-18}
C {b586_cap.sym} 2440 -2440 0 0 {name=Cext_47 value=501.967e-18}
C {b586_cap.sym} 2580 -2440 0 0 {name=Cext_48 value=734.815e-18}
C {b586_cap.sym} 2720 -2440 0 0 {name=Cext_49 value=14.2084e-18}
C {b586_cap.sym} 2860 -2440 0 0 {name=Cext_50 value=14.2084e-18}
C {b586_cap.sym} 3000 -2440 0 0 {name=Cext_51 value=0.735115e-18}
C {b586_cap.sym} 3140 -2440 0 0 {name=Cext_52 value=12.0025e-18}
C {b586_cap.sym} 3280 -2440 0 0 {name=Cext_53 value=331.598e-18}
C {b586_cap.sym} 3420 -2440 0 0 {name=Cext_54 value=14.2084e-18}
C {b586_cap.sym} 3560 -2440 0 0 {name=Cext_55 value=0.735115e-18}
C {b586_cap.sym} 3700 -2440 0 0 {name=Cext_56 value=12.0025e-18}
C {b586_cap.sym} 3840 -2440 0 0 {name=Cext_57 value=331.598e-18}
C {b586_cap.sym} 3980 -2440 0 0 {name=Cext_58 value=0.735115e-18}
C {b586_cap.sym} 4120 -2440 0 0 {name=Cext_59 value=14.9704e-18}
C {b586_cap.sym} 4260 -2440 0 0 {name=Cext_60 value=341.848e-18}
C {b586_cap.sym} 200 -2280 0 0 {name=Cext_61 value=14.2084e-18}
C {b586_cap.sym} 340 -2280 0 0 {name=Cext_62 value=14.2084e-18}
C {b586_cap.sym} 480 -2280 0 0 {name=Cext_63 value=0.735115e-18}
C {b586_cap.sym} 620 -2280 0 0 {name=Cext_64 value=0.541131e-18}
C {b586_cap.sym} 760 -2280 0 0 {name=Cext_65 value=12.0025e-18}
C {b586_cap.sym} 900 -2280 0 0 {name=Cext_66 value=331.598e-18}
C {b586_cap.sym} 1040 -2280 0 0 {name=Cext_67 value=0.735115e-18}
C {b586_cap.sym} 1180 -2280 0 0 {name=Cext_68 value=18.2327e-18}
C {b586_cap.sym} 1320 -2280 0 0 {name=Cext_69 value=12.0025e-18}
C {b586_cap.sym} 1460 -2280 0 0 {name=Cext_70 value=331.598e-18}
C {b586_cap.sym} 1600 -2280 0 0 {name=Cext_71 value=14.2084e-18}
C {b586_cap.sym} 1740 -2280 0 0 {name=Cext_72 value=0.735115e-18}
C {b586_cap.sym} 1880 -2280 0 0 {name=Cext_73 value=0.167332e-18}
C {b586_cap.sym} 2020 -2280 0 0 {name=Cext_74 value=12.0025e-18}
C {b586_cap.sym} 2160 -2280 0 0 {name=Cext_75 value=331.598e-18}
C {b586_cap.sym} 2300 -2280 0 0 {name=Cext_76 value=0.735115e-18}
C {b586_cap.sym} 2440 -2280 0 0 {name=Cext_77 value=12.0025e-18}
C {b586_cap.sym} 2580 -2280 0 0 {name=Cext_78 value=331.598e-18}
C {b586_cap.sym} 2720 -2280 0 0 {name=Cext_79 value=0.524321e-18}
C {b586_cap.sym} 2860 -2280 0 0 {name=Cext_80 value=19.0458e-18}
C {b586_cap.sym} 3000 -2280 0 0 {name=Cext_81 value=31.1754e-18}
C {b586_cap.sym} 3140 -2280 0 0 {name=Cext_82 value=12.6539e-18}
C {b586_cap.sym} 3280 -2280 0 0 {name=Cext_83 value=12.6539e-18}
C {b586_cap.sym} 3420 -2280 0 0 {name=Cext_84 value=30.9049e-18}
C {b586_cap.sym} 3560 -2280 0 0 {name=Cext_85 value=903.669e-18}
C {b586_cap.sym} 3700 -2280 0 0 {name=Cext_86 value=1.48902f}
C {b586_cap.sym} 3840 -2280 0 0 {name=Cext_87 value=15.5101e-18}
C {b586_cap.sym} 3980 -2280 0 0 {name=Cext_88 value=1.65454e-18}
C {b586_cap.sym} 4120 -2280 0 0 {name=Cext_89 value=19.0458e-18}
C {b586_cap.sym} 4260 -2280 0 0 {name=Cext_90 value=0.855051e-18}
C {b586_cap.sym} 200 -2120 0 0 {name=Cext_91 value=24.3204e-18}
C {b586_cap.sym} 340 -2120 0 0 {name=Cext_92 value=527.822e-18}
C {b586_cap.sym} 480 -2120 0 0 {name=Cext_93 value=1.65454e-18}
C {b586_cap.sym} 620 -2120 0 0 {name=Cext_94 value=0.524321e-18}
C {b586_cap.sym} 760 -2120 0 0 {name=Cext_95 value=5.91722e-18}
C {b586_cap.sym} 900 -2120 0 0 {name=Cext_96 value=24.3204e-18}
C {b586_cap.sym} 1040 -2120 0 0 {name=Cext_97 value=541.141e-18}
C {b586_cap.sym} 1180 -2120 0 0 {name=Cext_98 value=15.5101e-18}
C {b586_cap.sym} 1320 -2120 0 0 {name=Cext_99 value=0.120904e-18}
C {b586_cap.sym} 1460 -2120 0 0 {name=Cext_100 value=0.524321e-18}
C {b586_cap.sym} 1600 -2120 0 0 {name=Cext_101 value=2.26884e-18}
C {b586_cap.sym} 1740 -2120 0 0 {name=Cext_102 value=5.91722e-18}
C {b586_cap.sym} 1880 -2120 0 0 {name=Cext_103 value=24.2823e-18}
C {b586_cap.sym} 2020 -2120 0 0 {name=Cext_104 value=541.141e-18}
C {b586_cap.sym} 2160 -2120 0 0 {name=Cext_105 value=0.247176e-18}
C {b586_cap.sym} 2300 -2120 0 0 {name=Cext_106 value=19.0458e-18}
C {b586_cap.sym} 2440 -2120 0 0 {name=Cext_107 value=2.29766e-18}
C {b586_cap.sym} 2580 -2120 0 0 {name=Cext_108 value=0.855051e-18}
C {b586_cap.sym} 2720 -2120 0 0 {name=Cext_109 value=24.3204e-18}
C {b586_cap.sym} 2860 -2120 0 0 {name=Cext_110 value=527.822e-18}
C {b586_cap.sym} 3000 -2120 0 0 {name=Cext_111 value=4.91263e-18}
C {b586_cap.sym} 3140 -2120 0 0 {name=Cext_112 value=1.31773e-18}
C {b586_cap.sym} 3280 -2120 0 0 {name=Cext_113 value=0.253448e-18}
C {b586_cap.sym} 3420 -2120 0 0 {name=Cext_114 value=19.777e-18}
C {b586_cap.sym} 3560 -2120 0 0 {name=Cext_115 value=103.246e-18}
C {b586_cap.sym} 3700 -2120 0 0 {name=Cext_116 value=490.2e-18}
C {b586_cap.sym} 3840 -2120 0 0 {name=Cext_117 value=5.91722e-18}
C {b586_cap.sym} 3980 -2120 0 0 {name=Cext_118 value=0.253448e-18}
C {b586_cap.sym} 4120 -2120 0 0 {name=Cext_119 value=19.777e-18}
C {b586_cap.sym} 4260 -2120 0 0 {name=Cext_120 value=0.820484e-18}
C {b586_cap.sym} 200 -1960 0 0 {name=Cext_121 value=91.632e-18}
C {b586_cap.sym} 340 -1960 0 0 {name=Cext_122 value=490.2e-18}
C {b586_cap.sym} 480 -1960 0 0 {name=Cext_123 value=15.5101e-18}
C {b586_cap.sym} 620 -1960 0 0 {name=Cext_124 value=111.854e-18}
C {b586_cap.sym} 760 -1960 0 0 {name=Cext_125 value=490.996e-18}
C {b586_cap.sym} 900 -1960 0 0 {name=Cext_126 value=100.194e-18}
C {b586_cap.sym} 1040 -1960 0 0 {name=Cext_127 value=481.031e-18}
C {b586_cap.sym} 1180 -1960 0 0 {name=Cext_128 value=15.5101e-18}
C {b586_cap.sym} 1320 -1960 0 0 {name=Cext_129 value=94.7854e-18}
C {b586_cap.sym} 1460 -1960 0 0 {name=Cext_130 value=481.031e-18}
C {b586_cap.sym} 1600 -1960 0 0 {name=Cext_131 value=95.5187e-18}
C {b586_cap.sym} 1740 -1960 0 0 {name=Cext_132 value=481.031e-18}
C {b586_cap.sym} 1880 -1960 0 0 {name=Cext_133 value=15.5101e-18}
C {b586_cap.sym} 2020 -1960 0 0 {name=Cext_134 value=95.1057e-18}
C {b586_cap.sym} 2160 -1960 0 0 {name=Cext_135 value=481.031e-18}
C {b586_cap.sym} 2300 -1960 0 0 {name=Cext_136 value=99.5028e-18}
C {b586_cap.sym} 2440 -1960 0 0 {name=Cext_137 value=480.311e-18}
C {b586_cap.sym} 2580 -1960 0 0 {name=Cext_138 value=3.08988f}
C {b586_cap.sym} 2720 -1960 0 0 {name=Cext_139 value=18.9647e-18}
C {b586_cap.sym} 2860 -1960 0 0 {name=Cext_140 value=847.105e-18}
C {b586_cap.sym} 3000 -1960 0 0 {name=Cext_141 value=735.082e-18}
C {b586_cap.sym} 3140 -1960 0 0 {name=Cext_142 value=332.534e-18}
C {b586_cap.sym} 3280 -1960 0 0 {name=Cext_143 value=197.625e-18}
C {b586_cap.sym} 3420 -1960 0 0 {name=Cext_144 value=741.197e-18}
C {b586_cap.sym} 3560 -1960 0 0 {name=Cext_145 value=1.07019f}
C {b586_cap.sym} 3700 -1960 0 0 {name=Cext_146 value=42.3574e-18}
C {b586_cap.sym} 3840 -1960 0 0 {name=Cext_147 value=0.214735e-18}
C {b586_cap.sym} 3980 -1960 0 0 {name=Cext_148 value=1.39679f}
C {b586_cap.sym} 4120 -1960 0 0 {name=Cext_149 value=1.09491e-18}
C {b586_cap.sym} 4260 -1960 0 0 {name=Cext_150 value=14.8445f}
C {b586_cap.sym} 200 -1800 0 0 {name=Cext_151 value=1.78008f}
C {b586_cap.sym} 340 -1800 0 0 {name=Cext_152 value=3.1973e-18}
C {b586_cap.sym} 480 -1800 0 0 {name=Cext_153 value=683.913e-18}
C {b586_cap.sym} 620 -1800 0 0 {name=Cext_154 value=1.28399f}
C {b586_cap.sym} 760 -1800 0 0 {name=Cext_155 value=407.234e-18}
C {b586_cap.sym} 900 -1800 0 0 {name=Cext_156 value=0.457024e-18}
C {b586_cap.sym} 1040 -1800 0 0 {name=Cext_157 value=1.76096f}
C {b586_cap.sym} 1180 -1800 0 0 {name=Cext_158 value=3.38132f}
C {b586_cap.sym} 1320 -1800 0 0 {name=Cext_159 value=369.77e-18}
C {b586_cap.sym} 1460 -1800 0 0 {name=Cext_160 value=105.35e-18}
C {b586_cap.sym} 1600 -1800 0 0 {name=Cext_161 value=67.0643e-18}
C {b586_cap.sym} 1740 -1800 0 0 {name=Cext_162 value=66.6465e-18}
C {b586_cap.sym} 1880 -1800 0 0 {name=Cext_163 value=1.22759e-18}
C {b586_cap.sym} 2020 -1800 0 0 {name=Cext_164 value=66.4272e-18}
C {b586_cap.sym} 2160 -1800 0 0 {name=Cext_165 value=69.0247e-18}
C {b586_cap.sym} 2300 -1800 0 0 {name=Cext_166 value=5.54508f}
C {b586_cap.sym} 2440 -1800 0 0 {name=Cext_167 value=539.684e-18}
C {b586_cap.sym} 2580 -1800 0 0 {name=Cext_168 value=89.8574e-18}
C {b586_cap.sym} 2720 -1800 0 0 {name=Cext_169 value=66.3707e-18}
C {b586_cap.sym} 2860 -1800 0 0 {name=Cext_170 value=3.51936e-18}
C {b586_cap.sym} 3000 -1800 0 0 {name=Cext_171 value=478.72e-18}
C {b586_cap.sym} 3140 -1800 0 0 {name=Cext_172 value=85.5231e-18}
C {b586_cap.sym} 3280 -1800 0 0 {name=Cext_173 value=7.31884e-18}
C {b586_cap.sym} 3420 -1800 0 0 {name=Cext_174 value=2.47943f}
C {b586_cap.sym} 3560 -1800 0 0 {name=Cext_175 value=603.724e-18}
C {b586_cap.sym} 3700 -1800 0 0 {name=Cext_176 value=62.4898e-18}
C {b586_cap.sym} 3840 -1800 0 0 {name=Cext_177 value=270.036e-18}
C {b586_cap.sym} 3980 -1800 0 0 {name=Cext_178 value=1.22759e-18}
C {b586_cap.sym} 4120 -1800 0 0 {name=Cext_179 value=84.8402e-18}
C {b586_cap.sym} 4260 -1800 0 0 {name=Cext_180 value=85.2692e-18}
C {b586_cap.sym} 200 -1640 0 0 {name=Cext_181 value=1.59819f}
C {b586_cap.sym} 340 -1640 0 0 {name=Cext_182 value=541.399e-18}
C {b586_cap.sym} 480 -1640 0 0 {name=Cext_183 value=89.9071e-18}
C {b586_cap.sym} 620 -1640 0 0 {name=Cext_184 value=66.4466e-18}
C {b586_cap.sym} 760 -1640 0 0 {name=Cext_185 value=0.58192e-18}
C {b586_cap.sym} 900 -1640 0 0 {name=Cext_186 value=478.512e-18}
C {b586_cap.sym} 1040 -1640 0 0 {name=Cext_187 value=8.38671e-18}
C {b586_cap.sym} 1180 -1640 0 0 {name=Cext_188 value=3.36401f}
C {b586_cap.sym} 1320 -1640 0 0 {name=Cext_189 value=495.887e-18}
C {b586_cap.sym} 1460 -1640 0 0 {name=Cext_190 value=67.4106e-18}
C {b586_cap.sym} 1600 -1640 0 0 {name=Cext_191 value=1.22759e-18}
C {b586_cap.sym} 1740 -1640 0 0 {name=Cext_192 value=66.5915e-18}
C {b586_cap.sym} 1880 -1640 0 0 {name=Cext_193 value=1.54168f}
C {b586_cap.sym} 2020 -1640 0 0 {name=Cext_194 value=541.425e-18}
C {b586_cap.sym} 2160 -1640 0 0 {name=Cext_195 value=89.9115e-18}
C {b586_cap.sym} 2300 -1640 0 0 {name=Cext_196 value=66.4676e-18}
C {b586_cap.sym} 2440 -1640 0 0 {name=Cext_197 value=86.7912e-18}
C {b586_cap.sym} 2580 -1640 0 0 {name=Cext_198 value=478.512e-18}
C {b586_cap.sym} 2720 -1640 0 0 {name=Cext_199 value=69.0247e-18}
C {b586_cap.sym} 2860 -1640 0 0 {name=Cext_200 value=1.8489e-18}
C {b586_cap.sym} 3000 -1640 0 0 {name=Cext_201 value=5.71403f}
C {b586_cap.sym} 3140 -1640 0 0 {name=Cext_202 value=99.591e-18}
C {b586_cap.sym} 3280 -1640 0 0 {name=Cext_203 value=70.2523e-18}
C {b586_cap.sym} 3420 -1640 0 0 {name=Cext_204 value=248.615e-18}
C {b586_cap.sym} 3560 -1640 0 0 {name=Cext_205 value=1.56219f}
C {b586_cap.sym} 3700 -1640 0 0 {name=Cext_206 value=540.29e-18}
C {b586_cap.sym} 3840 -1640 0 0 {name=Cext_207 value=90.2237e-18}
C {b586_cap.sym} 3980 -1640 0 0 {name=Cext_208 value=71.5847e-18}
C {b586_cap.sym} 4120 -1640 0 0 {name=Cext_209 value=0.238401e-18}
C {b586_cap.sym} 4260 -1640 0 0 {name=Cext_210 value=480.244e-18}
C {b586_cap.sym} 200 -1480 0 0 {name=Cext_211 value=13.0714e-18}
C {b586_cap.sym} 340 -1480 0 0 {name=Cext_212 value=9.09587f}
C {b586_cap.sym} 480 -1480 0 0 {name=Cext_213 value=1.22759e-18}
C {b586_cap.sym} 620 -1480 0 0 {name=Cext_214 value=86.0785e-18}
C {b586_cap.sym} 760 -1480 0 0 {name=Cext_215 value=1.34059f}
C {b586_cap.sym} 900 -1480 0 0 {name=Cext_216 value=545.423e-18}
C {b586_cap.sym} 1040 -1480 0 0 {name=Cext_217 value=241.428e-18}
C {b586_cap.sym} 1180 -1480 0 0 {name=Cext_218 value=170.512e-18}
C {b586_cap.sym} 1320 -1480 0 0 {name=Cext_219 value=69.4934e-18}
C {b586_cap.sym} 1460 -1480 0 0 {name=Cext_220 value=478.512e-18}
C {b586_cap.sym} 1600 -1480 0 0 {name=Cext_221 value=9.92566e-18}
C {b586_cap.sym} 1740 -1480 0 0 {name=Cext_222 value=1.47054e-18}
C {b586_cap.sym} 1880 -1480 0 0 {name=Cext_223 value=10.5027f}
C {b586_cap.sym} 2020 -1480 0 0 {name=Cext_224 value=2.03967e-18}
C {b586_cap.sym} 2160 -1480 0 0 {name=Cext_225 value=2.27172f}
C {b586_cap.sym} 2300 -1480 0 0 {name=Cext_226 value=7.15985f}
C {b586_cap.sym} 2440 -1480 0 0 {name=Cext_227 value=360.612e-18}
C {b586_cap.sym} 2580 -1480 0 0 {name=Cext_228 value=824.601e-18}
C {b586_cap.sym} 2720 -1480 0 0 {name=Cext_229 value=60.8768e-18}
C {b586_cap.sym} 2860 -1480 0 0 {name=Cext_230 value=32.2826e-18}
C {b586_cap.sym} 3000 -1480 0 0 {name=Cext_231 value=34.4541e-18}
C {b586_cap.sym} 3140 -1480 0 0 {name=Cext_232 value=339.328e-18}
C {b586_cap.sym} 3280 -1480 0 0 {name=Cext_233 value=783.982e-18}
C {b586_cap.sym} 3420 -1480 0 0 {name=Cext_234 value=0.236884e-18}
C {b586_cap.sym} 3560 -1480 0 0 {name=Cext_235 value=0.311768e-18}
C {b586_cap.sym} 3700 -1480 0 0 {name=Cext_236 value=3.63074e-18}
C {b586_cap.sym} 3840 -1480 0 0 {name=Cext_237 value=193.075e-18}
C {b586_cap.sym} 3980 -1480 0 0 {name=Cext_238 value=5.36919e-18}
C {b586_cap.sym} 4120 -1480 0 0 {name=Cext_239 value=89.4959e-18}
C {b586_cap.sym} 4260 -1480 0 0 {name=Cext_240 value=11.6494f}
C {b586_cap.sym} 200 -1320 0 0 {name=Cext_241 value=15.8721e-18}
C {b586_cap.sym} 340 -1320 0 0 {name=Cext_242 value=0.145608e-18}
C {b586_cap.sym} 480 -1320 0 0 {name=Cext_243 value=156.801e-18}
C {b586_cap.sym} 620 -1320 0 0 {name=Cext_244 value=4.6575f}
C {b586_cap.sym} 760 -1320 0 0 {name=Cext_245 value=3.91955f}
C {b586_cap.sym} 900 -1320 0 0 {name=Cext_246 value=45.5207e-18}
C {b586_cap.sym} 1040 -1320 0 0 {name=Cext_247 value=6.1594e-18}
C {b586_cap.sym} 1180 -1320 0 0 {name=Cext_248 value=975.203e-18}
C {b586_cap.sym} 1320 -1320 0 0 {name=Cext_249 value=6.11366f}
C {b586_cap.sym} 1460 -1320 0 0 {name=Cext_250 value=70.5206e-18}
C {b586_cap.sym} 1600 -1320 0 0 {name=Cext_251 value=223.508e-18}
C {b586_cap.sym} 1740 -1320 0 0 {name=Cext_252 value=289.493e-18}
C {b586_cap.sym} 1880 -1320 0 0 {name=Cext_253 value=1.11756f}
C {b586_cap.sym} 2020 -1320 0 0 {name=Cext_254 value=12.9977e-18}
C {b586_cap.sym} 2160 -1320 0 0 {name=Cext_255 value=126.975e-18}
C {b586_cap.sym} 2300 -1320 0 0 {name=Cext_256 value=7.98667f}
C {b586_cap.sym} 2440 -1320 0 0 {name=Cext_257 value=3.0592e-18}
C {b586_cap.sym} 2580 -1320 0 0 {name=Cext_258 value=0.356062e-18}
C {b586_cap.sym} 2720 -1320 0 0 {name=Cext_259 value=152.428e-18}
C {b586_cap.sym} 2860 -1320 0 0 {name=Cext_260 value=519.69e-18}
C {b586_cap.sym} 3000 -1320 0 0 {name=Cext_261 value=6.39949e-18}
C {b586_cap.sym} 3140 -1320 0 0 {name=Cext_262 value=4.83147f}
C {b586_cap.sym} 3280 -1320 0 0 {name=Cext_263 value=1.32414f}
C {b586_cap.sym} 3420 -1320 0 0 {name=Cext_264 value=1.91233f}
C {b586_cap.sym} 3560 -1320 0 0 {name=Cext_265 value=6.41414e-18}
C {b586_cap.sym} 3700 -1320 0 0 {name=Cext_266 value=116.638e-18}
C {b586_cap.sym} 3840 -1320 0 0 {name=Cext_267 value=9.33416f}
C {b586_cap.sym} 3980 -1320 0 0 {name=Cext_268 value=2.50831f}
C {b586_cap.sym} 4120 -1320 0 0 {name=Cext_269 value=732.455e-18}
C {b586_cap.sym} 4260 -1320 0 0 {name=Cext_270 value=1.54255f}
C {b586_cap.sym} 200 -1160 0 0 {name=Cext_271 value=3.71289e-18}
C {b586_cap.sym} 340 -1160 0 0 {name=Cext_272 value=157.678e-18}
C {b586_cap.sym} 480 -1160 0 0 {name=Cext_273 value=49.6104e-18}
C {b586_cap.sym} 620 -1160 0 0 {name=Cext_274 value=147.156e-18}
C {b586_cap.sym} 760 -1160 0 0 {name=Cext_275 value=3.85011f}
C {b586_cap.sym} 900 -1160 0 0 {name=Cext_276 value=213.907e-18}
C {b586_cap.sym} 1040 -1160 0 0 {name=Cext_277 value=3.75278f}
C {b586_cap.sym} 1180 -1160 0 0 {name=Cext_278 value=2.77052e-18}
C {b586_cap.sym} 1320 -1160 0 0 {name=Cext_279 value=2.04066e-18}
C {b586_cap.sym} 1460 -1160 0 0 {name=Cext_280 value=3.71047f}
C {b586_cap.sym} 1600 -1160 0 0 {name=Cext_281 value=953.297e-18}
C {b586_cap.sym} 1740 -1160 0 0 {name=Cext_282 value=313.659e-18}
C {b586_cap.sym} 1880 -1160 0 0 {name=Cext_283 value=2.31913f}
C {b586_cap.sym} 2020 -1160 0 0 {name=Cext_284 value=598.224e-18}
C {b586_cap.sym} 2160 -1160 0 0 {name=Cext_285 value=12.2762f}
C {b586_cap.sym} 2300 -1160 0 0 {name=Cext_286 value=285.464e-18}
C {b586_cap.sym} 2440 -1160 0 0 {name=Cext_287 value=83.346e-18}
C {b586_cap.sym} 2580 -1160 0 0 {name=Cext_288 value=415.346e-18}
C {b586_cap.sym} 2720 -1160 0 0 {name=Cext_289 value=62.6373e-18}
C {b586_cap.sym} 2860 -1160 0 0 {name=Cext_290 value=158.562e-18}
C {b586_cap.sym} 3000 -1160 0 0 {name=Cext_291 value=591.385e-18}
C {b586_cap.sym} 3140 -1160 0 0 {name=Cext_292 value=1.27566f}
C {b586_cap.sym} 3280 -1160 0 0 {name=Cext_293 value=6.68835f}
C {b586_cap.sym} 3420 -1160 0 0 {name=Cext_294 value=708.188e-18}
C {b586_cap.sym} 3560 -1160 0 0 {name=Cext_295 value=11.0316e-18}
C {b586_cap.sym} 3700 -1160 0 0 {name=Cext_296 value=10.5784e-18}
C {b586_cap.sym} 3840 -1160 0 0 {name=Cext_297 value=29.0277e-18}
C {b586_cap.sym} 3980 -1160 0 0 {name=Cext_298 value=223.747e-18}
C {b586_cap.sym} 4120 -1160 0 0 {name=Cext_299 value=5.2939f}
C {b586_cap.sym} 4260 -1160 0 0 {name=Cext_300 value=394.468e-18}
C {b586_cap.sym} 200 -1000 0 0 {name=Cext_301 value=245.219e-18}
C {b586_cap.sym} 340 -1000 0 0 {name=Cext_302 value=1.39267f}
C {b586_cap.sym} 480 -1000 0 0 {name=Cext_303 value=2.03701f}
C {b586_cap.sym} 620 -1000 0 0 {name=Cext_304 value=364.135e-18}
C {b586_cap.sym} 760 -1000 0 0 {name=Cext_305 value=1.51724f}
C {b586_cap.sym} 900 -1000 0 0 {name=Cext_306 value=480.6e-18}
C {b586_cap.sym} 1040 -1000 0 0 {name=Cext_307 value=4.41403f}
C {b586_cap.sym} 1180 -1000 0 0 {name=Cext_308 value=4.95536f}
C {b586_cap.sym} 1320 -1000 0 0 {name=Cext_309 value=2.31262f}
C {b586_cap.sym} 1460 -1000 0 0 {name=Cext_310 value=2.22418f}
C {b586_cap.sym} 1600 -1000 0 0 {name=Cext_311 value=2.35423f}
C {b586_cap.sym} 1740 -1000 0 0 {name=Cext_312 value=2.28807f}
C {b586_cap.sym} 1880 -1000 0 0 {name=Cext_313 value=2.73371f}
C {b586_cap.sym} 2020 -1000 0 0 {name=Cext_314 value=6.4979f}
C {b586_cap.sym} 2160 -1000 0 0 {name=Cext_315 value=6.69786f}
C {b586_cap.sym} 2300 -1000 0 0 {name=Cext_316 value=1.94954f}
C {b586_cap.sym} 2440 -1000 0 0 {name=Cext_317 value=3.02926f}
C {b586_cap.sym} 2580 -1000 0 0 {name=Cext_318 value=2.16318f}
C {b586_cap.sym} 2720 -1000 0 0 {name=Cext_319 value=45.0447f}
C {b586_cap.sym} 2860 -1000 0 0 {name=Cext_320 value=30.7628f}
C {b586_cap.sym} 3000 -1000 0 0 {name=Cext_321 value=4.25325f}
C {b586_cap.sym} 3140 -1000 0 0 {name=Cext_322 value=2.48056f}
C {b586_cap.sym} 3280 -1000 0 0 {name=Cext_323 value=11.6562f}
C {b586_cap.sym} 3420 -1000 0 0 {name=Cext_324 value=8.8365f}
C {b586_cap.sym} 3560 -1000 0 0 {name=Cext_325 value=1.77779f}
C {b586_cap.sym} 3700 -1000 0 0 {name=Cext_326 value=1.42461f}
C {b586_cap.sym} 3840 -1000 0 0 {name=Cext_327 value=1.56685f}
C {b586_cap.sym} 3980 -1000 0 0 {name=Cext_328 value=18.8574f}
C {b586_cap.sym} 4120 -1000 0 0 {name=Cext_329 value=2.41436f}
C {devices/iopin.sym} 40 -2700 0 0 {name=p0 lab=c2}
C {devices/iopin.sym} 40 -2730 0 0 {name=p1 lab=d1}
C {devices/iopin.sym} 40 -2760 0 0 {name=p2 lab=d2}
C {devices/iopin.sym} 40 -2790 0 0 {name=p3 lab=d3}
C {devices/iopin.sym} 40 -2820 0 0 {name=p4 lab=d4}
C {devices/iopin.sym} 40 -2850 0 0 {name=p5 lab=d5}
C {devices/iopin.sym} 40 -2880 0 0 {name=p6 lab=n1}
C {devices/iopin.sym} 40 -2910 0 0 {name=p7 lab=r4}
C {devices/iopin.sym} 40 -2940 0 0 {name=p8 lab=b1b}
C {devices/iopin.sym} 40 -2970 0 0 {name=p9 lab=det}
C {devices/iopin.sym} 40 -3000 0 0 {name=p10 lab=r4n}
C {devices/iopin.sym} 40 -3030 0 0 {name=p11 lab=vb2}
C {devices/iopin.sym} 40 -3060 0 0 {name=p12 lab=vbe}
C {devices/iopin.sym} 40 -3090 0 0 {name=p13 lab=vd1}
C {devices/iopin.sym} 40 -3120 0 0 {name=p14 lab=vd2}
C {devices/iopin.sym} 40 -3150 0 0 {name=p15 lab=vdd}
C {devices/iopin.sym} 40 -3180 0 0 {name=p16 lab=vss}
C {devices/iopin.sym} 40 -3210 0 0 {name=p17 lab=dvbe}
C {devices/iopin.sym} 40 -3240 0 0 {name=p18 lab=kick}
C {devices/iopin.sym} 40 -3270 0 0 {name=p19 lab=vbe3}
C {devices/iopin.sym} 40 -3300 0 0 {name=p20 lab=vref}
C {devices/iopin.sym} 40 -3330 0 0 {name=p21 lab=iptat}
C {devices/iopin.sym} 40 -3360 0 0 {name=p22 lab=pbias}
C {devices/iopin.sym} 40 -3390 0 0 {name=p23 lab=pcasc}
C {devices/iopin.sym} 40 -3420 0 0 {name=p24 lab=n_2}
C {devices/iopin.sym} 40 -3450 0 0 {name=p25 lab=n_3}
C {devices/iopin.sym} 40 -3480 0 0 {name=p26 lab=n_4}
C {devices/iopin.sym} 40 -3510 0 0 {name=p27 lab=n_5}
C {devices/iopin.sym} 40 -3540 0 0 {name=p28 lab=n_6}
C {devices/iopin.sym} 40 -3570 0 0 {name=p29 lab=n_7}
C {devices/iopin.sym} 40 -3600 0 0 {name=p30 lab=n_8}
C {devices/iopin.sym} 40 -3630 0 0 {name=p31 lab=n_9}
C {devices/iopin.sym} 40 -3660 0 0 {name=p32 lab=n_10}
C {devices/iopin.sym} 40 -3690 0 0 {name=p33 lab=n_11}
C {devices/iopin.sym} 40 -3720 0 0 {name=p34 lab=n_12}
C {devices/iopin.sym} 40 -3750 0 0 {name=p35 lab=n_13}
C {devices/iopin.sym} 40 -3780 0 0 {name=p36 lab=n_14}
C {devices/iopin.sym} 40 -3810 0 0 {name=p37 lab=n_15}
C {devices/iopin.sym} 40 -3840 0 0 {name=p38 lab=n_16}
C {devices/iopin.sym} 40 -3870 0 0 {name=p39 lab=n_17}
C {devices/iopin.sym} 40 -3900 0 0 {name=p40 lab=n_18}
C {devices/iopin.sym} 40 -3930 0 0 {name=p41 lab=n_19}
C {devices/iopin.sym} 40 -3960 0 0 {name=p42 lab=n_21}
C {devices/iopin.sym} 40 -3990 0 0 {name=p43 lab=n_22}
C {devices/iopin.sym} 40 -4020 0 0 {name=p44 lab=n_23}
C {devices/iopin.sym} 40 -4050 0 0 {name=p45 lab=n_24}
C {devices/iopin.sym} 40 -4080 0 0 {name=p46 lab=n_25}
C {devices/iopin.sym} 40 -4110 0 0 {name=p47 lab=n_26}
C {devices/iopin.sym} 40 -4140 0 0 {name=p48 lab=n_27}
C {devices/iopin.sym} 40 -4170 0 0 {name=p49 lab=n_30}
C {devices/iopin.sym} 40 -4200 0 0 {name=p50 lab=n_31}
C {devices/iopin.sym} 40 -4230 0 0 {name=p51 lab=n_33}
C {devices/iopin.sym} 40 -4260 0 0 {name=p52 lab=n_34}
C {devices/iopin.sym} 40 -4290 0 0 {name=p53 lab=n_36}
C {devices/iopin.sym} 40 -4320 0 0 {name=p54 lab=n_37}
C {devices/lab_pin.sym} 200 -2630 0 0 {name=l1 lab=n_10}
C {devices/lab_pin.sym} 200 -2570 0 0 {name=l2 lab=n_11}
C {devices/lab_pin.sym} 340 -2630 0 0 {name=l3 lab=n_10}
C {devices/lab_pin.sym} 340 -2570 0 0 {name=l4 lab=n_3}
C {devices/lab_pin.sym} 480 -2630 0 0 {name=l5 lab=n_10}
C {devices/lab_pin.sym} 480 -2570 0 0 {name=l6 lab=vss}
C {devices/lab_pin.sym} 620 -2630 0 0 {name=l7 lab=n_10}
C {devices/lab_pin.sym} 620 -2570 0 0 {name=l8 lab=vss}
C {devices/lab_pin.sym} 760 -2630 0 0 {name=l9 lab=n_11}
C {devices/lab_pin.sym} 760 -2570 0 0 {name=l10 lab=n_12}
C {devices/lab_pin.sym} 900 -2630 0 0 {name=l11 lab=n_11}
C {devices/lab_pin.sym} 900 -2570 0 0 {name=l12 lab=n_3}
C {devices/lab_pin.sym} 1040 -2630 0 0 {name=l13 lab=n_11}
C {devices/lab_pin.sym} 1040 -2570 0 0 {name=l14 lab=vss}
C {devices/lab_pin.sym} 1180 -2630 0 0 {name=l15 lab=n_11}
C {devices/lab_pin.sym} 1180 -2570 0 0 {name=l16 lab=vss}
C {devices/lab_pin.sym} 1320 -2630 0 0 {name=l17 lab=n_12}
C {devices/lab_pin.sym} 1320 -2570 0 0 {name=l18 lab=n_13}
C {devices/lab_pin.sym} 1460 -2630 0 0 {name=l19 lab=n_12}
C {devices/lab_pin.sym} 1460 -2570 0 0 {name=l20 lab=vss}
C {devices/lab_pin.sym} 1600 -2630 0 0 {name=l21 lab=n_12}
C {devices/lab_pin.sym} 1600 -2570 0 0 {name=l22 lab=vss}
C {devices/lab_pin.sym} 1740 -2630 0 0 {name=l23 lab=n_13}
C {devices/lab_pin.sym} 1740 -2570 0 0 {name=l24 lab=n_14}
C {devices/lab_pin.sym} 1880 -2630 0 0 {name=l25 lab=n_13}
C {devices/lab_pin.sym} 1880 -2570 0 0 {name=l26 lab=vss}
C {devices/lab_pin.sym} 2020 -2630 0 0 {name=l27 lab=n_13}
C {devices/lab_pin.sym} 2020 -2570 0 0 {name=l28 lab=vss}
C {devices/lab_pin.sym} 2160 -2630 0 0 {name=l29 lab=n_14}
C {devices/lab_pin.sym} 2160 -2570 0 0 {name=l30 lab=n_15}
C {devices/lab_pin.sym} 2300 -2630 0 0 {name=l31 lab=n_14}
C {devices/lab_pin.sym} 2300 -2570 0 0 {name=l32 lab=vss}
C {devices/lab_pin.sym} 2440 -2630 0 0 {name=l33 lab=n_14}
C {devices/lab_pin.sym} 2440 -2570 0 0 {name=l34 lab=vss}
C {devices/lab_pin.sym} 2580 -2630 0 0 {name=l35 lab=n_15}
C {devices/lab_pin.sym} 2580 -2570 0 0 {name=l36 lab=n_16}
C {devices/lab_pin.sym} 2720 -2630 0 0 {name=l37 lab=n_15}
C {devices/lab_pin.sym} 2720 -2570 0 0 {name=l38 lab=vss}
C {devices/lab_pin.sym} 2860 -2630 0 0 {name=l39 lab=n_15}
C {devices/lab_pin.sym} 2860 -2570 0 0 {name=l40 lab=vss}
C {devices/lab_pin.sym} 3000 -2630 0 0 {name=l41 lab=n_16}
C {devices/lab_pin.sym} 3000 -2570 0 0 {name=l42 lab=n_17}
C {devices/lab_pin.sym} 3140 -2630 0 0 {name=l43 lab=n_16}
C {devices/lab_pin.sym} 3140 -2570 0 0 {name=l44 lab=vss}
C {devices/lab_pin.sym} 3280 -2630 0 0 {name=l45 lab=n_16}
C {devices/lab_pin.sym} 3280 -2570 0 0 {name=l46 lab=vss}
C {devices/lab_pin.sym} 3420 -2630 0 0 {name=l47 lab=n_17}
C {devices/lab_pin.sym} 3420 -2570 0 0 {name=l48 lab=n_18}
C {devices/lab_pin.sym} 3560 -2630 0 0 {name=l49 lab=n_17}
C {devices/lab_pin.sym} 3560 -2570 0 0 {name=l50 lab=vss}
C {devices/lab_pin.sym} 3700 -2630 0 0 {name=l51 lab=n_17}
C {devices/lab_pin.sym} 3700 -2570 0 0 {name=l52 lab=vss}
C {devices/lab_pin.sym} 3840 -2630 0 0 {name=l53 lab=n_18}
C {devices/lab_pin.sym} 3840 -2570 0 0 {name=l54 lab=vss}
C {devices/lab_pin.sym} 3980 -2630 0 0 {name=l55 lab=n_18}
C {devices/lab_pin.sym} 3980 -2570 0 0 {name=l56 lab=vss}
C {devices/lab_pin.sym} 4120 -2630 0 0 {name=l57 lab=n_19}
C {devices/lab_pin.sym} 4120 -2570 0 0 {name=l58 lab=n_31}
C {devices/lab_pin.sym} 4260 -2630 0 0 {name=l59 lab=n_19}
C {devices/lab_pin.sym} 4260 -2570 0 0 {name=l60 lab=n_33}
C {devices/lab_pin.sym} 200 -2470 0 0 {name=l61 lab=n_19}
C {devices/lab_pin.sym} 200 -2410 0 0 {name=l62 lab=n_36}
C {devices/lab_pin.sym} 340 -2470 0 0 {name=l63 lab=n_19}
C {devices/lab_pin.sym} 340 -2410 0 0 {name=l64 lab=n_37}
C {devices/lab_pin.sym} 480 -2470 0 0 {name=l65 lab=n_19}
C {devices/lab_pin.sym} 480 -2410 0 0 {name=l66 lab=dvbe}
C {devices/lab_pin.sym} 620 -2470 0 0 {name=l67 lab=n_19}
C {devices/lab_pin.sym} 620 -2410 0 0 {name=l68 lab=pbias}
C {devices/lab_pin.sym} 760 -2470 0 0 {name=l69 lab=n_19}
C {devices/lab_pin.sym} 760 -2410 0 0 {name=l70 lab=vb2}
C {devices/lab_pin.sym} 900 -2470 0 0 {name=l71 lab=n_19}
C {devices/lab_pin.sym} 900 -2410 0 0 {name=l72 lab=vbe3}
C {devices/lab_pin.sym} 1040 -2470 0 0 {name=l73 lab=n_19}
C {devices/lab_pin.sym} 1040 -2410 0 0 {name=l74 lab=vd1}
C {devices/lab_pin.sym} 1180 -2470 0 0 {name=l75 lab=n_19}
C {devices/lab_pin.sym} 1180 -2410 0 0 {name=l76 lab=vd2}
C {devices/lab_pin.sym} 1320 -2470 0 0 {name=l77 lab=n_19}
C {devices/lab_pin.sym} 1320 -2410 0 0 {name=l78 lab=vref}
C {devices/lab_pin.sym} 1460 -2470 0 0 {name=l79 lab=n_19}
C {devices/lab_pin.sym} 1460 -2410 0 0 {name=l80 lab=vss}
C {devices/lab_pin.sym} 1600 -2470 0 0 {name=l81 lab=n_19}
C {devices/lab_pin.sym} 1600 -2410 0 0 {name=l82 lab=vss}
C {devices/lab_pin.sym} 1740 -2470 0 0 {name=l83 lab=n_2}
C {devices/lab_pin.sym} 1740 -2410 0 0 {name=l84 lab=n_3}
C {devices/lab_pin.sym} 1880 -2470 0 0 {name=l85 lab=n_2}
C {devices/lab_pin.sym} 1880 -2410 0 0 {name=l86 lab=n_6}
C {devices/lab_pin.sym} 2020 -2470 0 0 {name=l87 lab=n_2}
C {devices/lab_pin.sym} 2020 -2410 0 0 {name=l88 lab=n_7}
C {devices/lab_pin.sym} 2160 -2470 0 0 {name=l89 lab=n_2}
C {devices/lab_pin.sym} 2160 -2410 0 0 {name=l90 lab=n_8}
C {devices/lab_pin.sym} 2300 -2470 0 0 {name=l91 lab=n_2}
C {devices/lab_pin.sym} 2300 -2410 0 0 {name=l92 lab=n_9}
C {devices/lab_pin.sym} 2440 -2470 0 0 {name=l93 lab=n_2}
C {devices/lab_pin.sym} 2440 -2410 0 0 {name=l94 lab=vss}
C {devices/lab_pin.sym} 2580 -2470 0 0 {name=l95 lab=n_2}
C {devices/lab_pin.sym} 2580 -2410 0 0 {name=l96 lab=vss}
C {devices/lab_pin.sym} 2720 -2470 0 0 {name=l97 lab=n_21}
C {devices/lab_pin.sym} 2720 -2410 0 0 {name=l98 lab=n_22}
C {devices/lab_pin.sym} 2860 -2470 0 0 {name=l99 lab=n_21}
C {devices/lab_pin.sym} 2860 -2410 0 0 {name=l100 lab=n_27}
C {devices/lab_pin.sym} 3000 -2470 0 0 {name=l101 lab=n_21}
C {devices/lab_pin.sym} 3000 -2410 0 0 {name=l102 lab=b1b}
C {devices/lab_pin.sym} 3140 -2470 0 0 {name=l103 lab=n_21}
C {devices/lab_pin.sym} 3140 -2410 0 0 {name=l104 lab=vss}
C {devices/lab_pin.sym} 3280 -2470 0 0 {name=l105 lab=n_21}
C {devices/lab_pin.sym} 3280 -2410 0 0 {name=l106 lab=vss}
C {devices/lab_pin.sym} 3420 -2470 0 0 {name=l107 lab=n_22}
C {devices/lab_pin.sym} 3420 -2410 0 0 {name=l108 lab=n_23}
C {devices/lab_pin.sym} 3560 -2470 0 0 {name=l109 lab=n_22}
C {devices/lab_pin.sym} 3560 -2410 0 0 {name=l110 lab=b1b}
C {devices/lab_pin.sym} 3700 -2470 0 0 {name=l111 lab=n_22}
C {devices/lab_pin.sym} 3700 -2410 0 0 {name=l112 lab=vss}
C {devices/lab_pin.sym} 3840 -2470 0 0 {name=l113 lab=n_22}
C {devices/lab_pin.sym} 3840 -2410 0 0 {name=l114 lab=vss}
C {devices/lab_pin.sym} 3980 -2470 0 0 {name=l115 lab=n_23}
C {devices/lab_pin.sym} 3980 -2410 0 0 {name=l116 lab=b1b}
C {devices/lab_pin.sym} 4120 -2470 0 0 {name=l117 lab=n_23}
C {devices/lab_pin.sym} 4120 -2410 0 0 {name=l118 lab=vss}
C {devices/lab_pin.sym} 4260 -2470 0 0 {name=l119 lab=n_23}
C {devices/lab_pin.sym} 4260 -2410 0 0 {name=l120 lab=vss}
C {devices/lab_pin.sym} 200 -2310 0 0 {name=l121 lab=n_24}
C {devices/lab_pin.sym} 200 -2250 0 0 {name=l122 lab=n_25}
C {devices/lab_pin.sym} 340 -2310 0 0 {name=l123 lab=n_24}
C {devices/lab_pin.sym} 340 -2250 0 0 {name=l124 lab=n_26}
C {devices/lab_pin.sym} 480 -2310 0 0 {name=l125 lab=n_24}
C {devices/lab_pin.sym} 480 -2250 0 0 {name=l126 lab=b1b}
C {devices/lab_pin.sym} 620 -2310 0 0 {name=l127 lab=n_24}
C {devices/lab_pin.sym} 620 -2250 0 0 {name=l128 lab=det}
C {devices/lab_pin.sym} 760 -2310 0 0 {name=l129 lab=n_24}
C {devices/lab_pin.sym} 760 -2250 0 0 {name=l130 lab=vss}
C {devices/lab_pin.sym} 900 -2310 0 0 {name=l131 lab=n_24}
C {devices/lab_pin.sym} 900 -2250 0 0 {name=l132 lab=vss}
C {devices/lab_pin.sym} 1040 -2310 0 0 {name=l133 lab=n_25}
C {devices/lab_pin.sym} 1040 -2250 0 0 {name=l134 lab=b1b}
C {devices/lab_pin.sym} 1180 -2310 0 0 {name=l135 lab=n_25}
C {devices/lab_pin.sym} 1180 -2250 0 0 {name=l136 lab=det}
C {devices/lab_pin.sym} 1320 -2310 0 0 {name=l137 lab=n_25}
C {devices/lab_pin.sym} 1320 -2250 0 0 {name=l138 lab=vss}
C {devices/lab_pin.sym} 1460 -2310 0 0 {name=l139 lab=n_25}
C {devices/lab_pin.sym} 1460 -2250 0 0 {name=l140 lab=vss}
C {devices/lab_pin.sym} 1600 -2310 0 0 {name=l141 lab=n_26}
C {devices/lab_pin.sym} 1600 -2250 0 0 {name=l142 lab=n_27}
C {devices/lab_pin.sym} 1740 -2310 0 0 {name=l143 lab=n_26}
C {devices/lab_pin.sym} 1740 -2250 0 0 {name=l144 lab=b1b}
C {devices/lab_pin.sym} 1880 -2310 0 0 {name=l145 lab=n_26}
C {devices/lab_pin.sym} 1880 -2250 0 0 {name=l146 lab=det}
C {devices/lab_pin.sym} 2020 -2310 0 0 {name=l147 lab=n_26}
C {devices/lab_pin.sym} 2020 -2250 0 0 {name=l148 lab=vss}
C {devices/lab_pin.sym} 2160 -2310 0 0 {name=l149 lab=n_26}
C {devices/lab_pin.sym} 2160 -2250 0 0 {name=l150 lab=vss}
C {devices/lab_pin.sym} 2300 -2310 0 0 {name=l151 lab=n_27}
C {devices/lab_pin.sym} 2300 -2250 0 0 {name=l152 lab=b1b}
C {devices/lab_pin.sym} 2440 -2310 0 0 {name=l153 lab=n_27}
C {devices/lab_pin.sym} 2440 -2250 0 0 {name=l154 lab=vss}
C {devices/lab_pin.sym} 2580 -2310 0 0 {name=l155 lab=n_27}
C {devices/lab_pin.sym} 2580 -2250 0 0 {name=l156 lab=vss}
C {devices/lab_pin.sym} 2720 -2310 0 0 {name=l157 lab=n_3}
C {devices/lab_pin.sym} 2720 -2250 0 0 {name=l158 lab=n_4}
C {devices/lab_pin.sym} 2860 -2310 0 0 {name=l159 lab=n_3}
C {devices/lab_pin.sym} 2860 -2250 0 0 {name=l160 lab=n_5}
C {devices/lab_pin.sym} 3000 -2310 0 0 {name=l161 lab=n_3}
C {devices/lab_pin.sym} 3000 -2250 0 0 {name=l162 lab=n_6}
C {devices/lab_pin.sym} 3140 -2310 0 0 {name=l163 lab=n_3}
C {devices/lab_pin.sym} 3140 -2250 0 0 {name=l164 lab=n_7}
C {devices/lab_pin.sym} 3280 -2310 0 0 {name=l165 lab=n_3}
C {devices/lab_pin.sym} 3280 -2250 0 0 {name=l166 lab=n_8}
C {devices/lab_pin.sym} 3420 -2310 0 0 {name=l167 lab=n_3}
C {devices/lab_pin.sym} 3420 -2250 0 0 {name=l168 lab=n_9}
C {devices/lab_pin.sym} 3560 -2310 0 0 {name=l169 lab=n_3}
C {devices/lab_pin.sym} 3560 -2250 0 0 {name=l170 lab=vss}
C {devices/lab_pin.sym} 3700 -2310 0 0 {name=l171 lab=n_3}
C {devices/lab_pin.sym} 3700 -2250 0 0 {name=l172 lab=vss}
C {devices/lab_pin.sym} 3840 -2310 0 0 {name=l173 lab=n_30}
C {devices/lab_pin.sym} 3840 -2250 0 0 {name=l174 lab=n_31}
C {devices/lab_pin.sym} 3980 -2310 0 0 {name=l175 lab=n_30}
C {devices/lab_pin.sym} 3980 -2250 0 0 {name=l176 lab=dvbe}
C {devices/lab_pin.sym} 4120 -2310 0 0 {name=l177 lab=n_30}
C {devices/lab_pin.sym} 4120 -2250 0 0 {name=l178 lab=pbias}
C {devices/lab_pin.sym} 4260 -2310 0 0 {name=l179 lab=n_30}
C {devices/lab_pin.sym} 4260 -2250 0 0 {name=l180 lab=vb2}
C {devices/lab_pin.sym} 200 -2150 0 0 {name=l181 lab=n_30}
C {devices/lab_pin.sym} 200 -2090 0 0 {name=l182 lab=vss}
C {devices/lab_pin.sym} 340 -2150 0 0 {name=l183 lab=n_30}
C {devices/lab_pin.sym} 340 -2090 0 0 {name=l184 lab=vss}
C {devices/lab_pin.sym} 480 -2150 0 0 {name=l185 lab=n_31}
C {devices/lab_pin.sym} 480 -2090 0 0 {name=l186 lab=dvbe}
C {devices/lab_pin.sym} 620 -2150 0 0 {name=l187 lab=n_31}
C {devices/lab_pin.sym} 620 -2090 0 0 {name=l188 lab=pbias}
C {devices/lab_pin.sym} 760 -2150 0 0 {name=l189 lab=n_31}
C {devices/lab_pin.sym} 760 -2090 0 0 {name=l190 lab=vb2}
C {devices/lab_pin.sym} 900 -2150 0 0 {name=l191 lab=n_31}
C {devices/lab_pin.sym} 900 -2090 0 0 {name=l192 lab=vss}
C {devices/lab_pin.sym} 1040 -2150 0 0 {name=l193 lab=n_31}
C {devices/lab_pin.sym} 1040 -2090 0 0 {name=l194 lab=vss}
C {devices/lab_pin.sym} 1180 -2150 0 0 {name=l195 lab=n_33}
C {devices/lab_pin.sym} 1180 -2090 0 0 {name=l196 lab=n_34}
C {devices/lab_pin.sym} 1320 -2150 0 0 {name=l197 lab=n_33}
C {devices/lab_pin.sym} 1320 -2090 0 0 {name=l198 lab=b1b}
C {devices/lab_pin.sym} 1460 -2150 0 0 {name=l199 lab=n_33}
C {devices/lab_pin.sym} 1460 -2090 0 0 {name=l200 lab=pcasc}
C {devices/lab_pin.sym} 1600 -2150 0 0 {name=l201 lab=n_33}
C {devices/lab_pin.sym} 1600 -2090 0 0 {name=l202 lab=vbe3}
C {devices/lab_pin.sym} 1740 -2150 0 0 {name=l203 lab=n_33}
C {devices/lab_pin.sym} 1740 -2090 0 0 {name=l204 lab=vd1}
C {devices/lab_pin.sym} 1880 -2150 0 0 {name=l205 lab=n_33}
C {devices/lab_pin.sym} 1880 -2090 0 0 {name=l206 lab=vss}
C {devices/lab_pin.sym} 2020 -2150 0 0 {name=l207 lab=n_33}
C {devices/lab_pin.sym} 2020 -2090 0 0 {name=l208 lab=vss}
C {devices/lab_pin.sym} 2160 -2150 0 0 {name=l209 lab=n_34}
C {devices/lab_pin.sym} 2160 -2090 0 0 {name=l210 lab=b1b}
C {devices/lab_pin.sym} 2300 -2150 0 0 {name=l211 lab=n_34}
C {devices/lab_pin.sym} 2300 -2090 0 0 {name=l212 lab=pcasc}
C {devices/lab_pin.sym} 2440 -2150 0 0 {name=l213 lab=n_34}
C {devices/lab_pin.sym} 2440 -2090 0 0 {name=l214 lab=vbe3}
C {devices/lab_pin.sym} 2580 -2150 0 0 {name=l215 lab=n_34}
C {devices/lab_pin.sym} 2580 -2090 0 0 {name=l216 lab=vd1}
C {devices/lab_pin.sym} 2720 -2150 0 0 {name=l217 lab=n_34}
C {devices/lab_pin.sym} 2720 -2090 0 0 {name=l218 lab=vss}
C {devices/lab_pin.sym} 2860 -2150 0 0 {name=l219 lab=n_34}
C {devices/lab_pin.sym} 2860 -2090 0 0 {name=l220 lab=vss}
C {devices/lab_pin.sym} 3000 -2150 0 0 {name=l221 lab=n_36}
C {devices/lab_pin.sym} 3000 -2090 0 0 {name=l222 lab=n_37}
C {devices/lab_pin.sym} 3140 -2150 0 0 {name=l223 lab=n_36}
C {devices/lab_pin.sym} 3140 -2090 0 0 {name=l224 lab=dvbe}
C {devices/lab_pin.sym} 3280 -2150 0 0 {name=l225 lab=n_36}
C {devices/lab_pin.sym} 3280 -2090 0 0 {name=l226 lab=pbias}
C {devices/lab_pin.sym} 3420 -2150 0 0 {name=l227 lab=n_36}
C {devices/lab_pin.sym} 3420 -2090 0 0 {name=l228 lab=vref}
C {devices/lab_pin.sym} 3560 -2150 0 0 {name=l229 lab=n_36}
C {devices/lab_pin.sym} 3560 -2090 0 0 {name=l230 lab=vss}
C {devices/lab_pin.sym} 3700 -2150 0 0 {name=l231 lab=n_36}
C {devices/lab_pin.sym} 3700 -2090 0 0 {name=l232 lab=vss}
C {devices/lab_pin.sym} 3840 -2150 0 0 {name=l233 lab=n_37}
C {devices/lab_pin.sym} 3840 -2090 0 0 {name=l234 lab=dvbe}
C {devices/lab_pin.sym} 3980 -2150 0 0 {name=l235 lab=n_37}
C {devices/lab_pin.sym} 3980 -2090 0 0 {name=l236 lab=pbias}
C {devices/lab_pin.sym} 4120 -2150 0 0 {name=l237 lab=n_37}
C {devices/lab_pin.sym} 4120 -2090 0 0 {name=l238 lab=vbe3}
C {devices/lab_pin.sym} 4260 -2150 0 0 {name=l239 lab=n_37}
C {devices/lab_pin.sym} 4260 -2090 0 0 {name=l240 lab=vd2}
C {devices/lab_pin.sym} 200 -1990 0 0 {name=l241 lab=n_37}
C {devices/lab_pin.sym} 200 -1930 0 0 {name=l242 lab=vss}
C {devices/lab_pin.sym} 340 -1990 0 0 {name=l243 lab=n_37}
C {devices/lab_pin.sym} 340 -1930 0 0 {name=l244 lab=vss}
C {devices/lab_pin.sym} 480 -1990 0 0 {name=l245 lab=n_4}
C {devices/lab_pin.sym} 480 -1930 0 0 {name=l246 lab=n_5}
C {devices/lab_pin.sym} 620 -1990 0 0 {name=l247 lab=n_4}
C {devices/lab_pin.sym} 620 -1930 0 0 {name=l248 lab=vss}
C {devices/lab_pin.sym} 760 -1990 0 0 {name=l249 lab=n_4}
C {devices/lab_pin.sym} 760 -1930 0 0 {name=l250 lab=vss}
C {devices/lab_pin.sym} 900 -1990 0 0 {name=l251 lab=n_5}
C {devices/lab_pin.sym} 900 -1930 0 0 {name=l252 lab=vss}
C {devices/lab_pin.sym} 1040 -1990 0 0 {name=l253 lab=n_5}
C {devices/lab_pin.sym} 1040 -1930 0 0 {name=l254 lab=vss}
C {devices/lab_pin.sym} 1180 -1990 0 0 {name=l255 lab=n_6}
C {devices/lab_pin.sym} 1180 -1930 0 0 {name=l256 lab=n_7}
C {devices/lab_pin.sym} 1320 -1990 0 0 {name=l257 lab=n_6}
C {devices/lab_pin.sym} 1320 -1930 0 0 {name=l258 lab=vss}
C {devices/lab_pin.sym} 1460 -1990 0 0 {name=l259 lab=n_6}
C {devices/lab_pin.sym} 1460 -1930 0 0 {name=l260 lab=vss}
C {devices/lab_pin.sym} 1600 -1990 0 0 {name=l261 lab=n_7}
C {devices/lab_pin.sym} 1600 -1930 0 0 {name=l262 lab=vss}
C {devices/lab_pin.sym} 1740 -1990 0 0 {name=l263 lab=n_7}
C {devices/lab_pin.sym} 1740 -1930 0 0 {name=l264 lab=vss}
C {devices/lab_pin.sym} 1880 -1990 0 0 {name=l265 lab=n_8}
C {devices/lab_pin.sym} 1880 -1930 0 0 {name=l266 lab=n_9}
C {devices/lab_pin.sym} 2020 -1990 0 0 {name=l267 lab=n_8}
C {devices/lab_pin.sym} 2020 -1930 0 0 {name=l268 lab=vss}
C {devices/lab_pin.sym} 2160 -1990 0 0 {name=l269 lab=n_8}
C {devices/lab_pin.sym} 2160 -1930 0 0 {name=l270 lab=vss}
C {devices/lab_pin.sym} 2300 -1990 0 0 {name=l271 lab=n_9}
C {devices/lab_pin.sym} 2300 -1930 0 0 {name=l272 lab=vss}
C {devices/lab_pin.sym} 2440 -1990 0 0 {name=l273 lab=n_9}
C {devices/lab_pin.sym} 2440 -1930 0 0 {name=l274 lab=vss}
C {devices/lab_pin.sym} 2580 -1990 0 0 {name=l275 lab=b1b}
C {devices/lab_pin.sym} 2580 -1930 0 0 {name=l276 lab=det}
C {devices/lab_pin.sym} 2720 -1990 0 0 {name=l277 lab=b1b}
C {devices/lab_pin.sym} 2720 -1930 0 0 {name=l278 lab=kick}
C {devices/lab_pin.sym} 2860 -1990 0 0 {name=l279 lab=b1b}
C {devices/lab_pin.sym} 2860 -1930 0 0 {name=l280 lab=pbias}
C {devices/lab_pin.sym} 3000 -1990 0 0 {name=l281 lab=b1b}
C {devices/lab_pin.sym} 3000 -1930 0 0 {name=l282 lab=pcasc}
C {devices/lab_pin.sym} 3140 -1990 0 0 {name=l283 lab=b1b}
C {devices/lab_pin.sym} 3140 -1930 0 0 {name=l284 lab=r4}
C {devices/lab_pin.sym} 3280 -1990 0 0 {name=l285 lab=b1b}
C {devices/lab_pin.sym} 3280 -1930 0 0 {name=l286 lab=r4n}
C {devices/lab_pin.sym} 3420 -1990 0 0 {name=l287 lab=b1b}
C {devices/lab_pin.sym} 3420 -1930 0 0 {name=l288 lab=vbe}
C {devices/lab_pin.sym} 3560 -1990 0 0 {name=l289 lab=b1b}
C {devices/lab_pin.sym} 3560 -1930 0 0 {name=l290 lab=vbe3}
C {devices/lab_pin.sym} 3700 -1990 0 0 {name=l291 lab=b1b}
C {devices/lab_pin.sym} 3700 -1930 0 0 {name=l292 lab=vd1}
C {devices/lab_pin.sym} 3840 -1990 0 0 {name=l293 lab=b1b}
C {devices/lab_pin.sym} 3840 -1930 0 0 {name=l294 lab=vd2}
C {devices/lab_pin.sym} 3980 -1990 0 0 {name=l295 lab=b1b}
C {devices/lab_pin.sym} 3980 -1930 0 0 {name=l296 lab=vss}
C {devices/lab_pin.sym} 4120 -1990 0 0 {name=l297 lab=c2}
C {devices/lab_pin.sym} 4120 -1930 0 0 {name=l298 lab=det}
C {devices/lab_pin.sym} 4260 -1990 0 0 {name=l299 lab=c2}
C {devices/lab_pin.sym} 4260 -1930 0 0 {name=l300 lab=dvbe}
C {devices/lab_pin.sym} 200 -1830 0 0 {name=l301 lab=c2}
C {devices/lab_pin.sym} 200 -1770 0 0 {name=l302 lab=n1}
C {devices/lab_pin.sym} 340 -1830 0 0 {name=l303 lab=c2}
C {devices/lab_pin.sym} 340 -1770 0 0 {name=l304 lab=pbias}
C {devices/lab_pin.sym} 480 -1830 0 0 {name=l305 lab=c2}
C {devices/lab_pin.sym} 480 -1770 0 0 {name=l306 lab=pcasc}
C {devices/lab_pin.sym} 620 -1830 0 0 {name=l307 lab=c2}
C {devices/lab_pin.sym} 620 -1770 0 0 {name=l308 lab=vb2}
C {devices/lab_pin.sym} 760 -1830 0 0 {name=l309 lab=c2}
C {devices/lab_pin.sym} 760 -1770 0 0 {name=l310 lab=vbe}
C {devices/lab_pin.sym} 900 -1830 0 0 {name=l311 lab=c2}
C {devices/lab_pin.sym} 900 -1770 0 0 {name=l312 lab=vref}
C {devices/lab_pin.sym} 1040 -1830 0 0 {name=l313 lab=c2}
C {devices/lab_pin.sym} 1040 -1770 0 0 {name=l314 lab=vss}
C {devices/lab_pin.sym} 1180 -1830 0 0 {name=l315 lab=d1}
C {devices/lab_pin.sym} 1180 -1770 0 0 {name=l316 lab=d2}
C {devices/lab_pin.sym} 1320 -1830 0 0 {name=l317 lab=d1}
C {devices/lab_pin.sym} 1320 -1770 0 0 {name=l318 lab=d3}
C {devices/lab_pin.sym} 1460 -1830 0 0 {name=l319 lab=d1}
C {devices/lab_pin.sym} 1460 -1770 0 0 {name=l320 lab=d4}
C {devices/lab_pin.sym} 1600 -1830 0 0 {name=l321 lab=d1}
C {devices/lab_pin.sym} 1600 -1770 0 0 {name=l322 lab=d5}
C {devices/lab_pin.sym} 1740 -1830 0 0 {name=l323 lab=d1}
C {devices/lab_pin.sym} 1740 -1770 0 0 {name=l324 lab=det}
C {devices/lab_pin.sym} 1880 -1830 0 0 {name=l325 lab=d1}
C {devices/lab_pin.sym} 1880 -1770 0 0 {name=l326 lab=iptat}
C {devices/lab_pin.sym} 2020 -1830 0 0 {name=l327 lab=d1}
C {devices/lab_pin.sym} 2020 -1770 0 0 {name=l328 lab=kick}
C {devices/lab_pin.sym} 2160 -1830 0 0 {name=l329 lab=d1}
C {devices/lab_pin.sym} 2160 -1770 0 0 {name=l330 lab=n1}
C {devices/lab_pin.sym} 2300 -1830 0 0 {name=l331 lab=d1}
C {devices/lab_pin.sym} 2300 -1770 0 0 {name=l332 lab=pbias}
C {devices/lab_pin.sym} 2440 -1830 0 0 {name=l333 lab=d1}
C {devices/lab_pin.sym} 2440 -1770 0 0 {name=l334 lab=pcasc}
C {devices/lab_pin.sym} 2580 -1830 0 0 {name=l335 lab=d1}
C {devices/lab_pin.sym} 2580 -1770 0 0 {name=l336 lab=r4}
C {devices/lab_pin.sym} 2720 -1830 0 0 {name=l337 lab=d1}
C {devices/lab_pin.sym} 2720 -1770 0 0 {name=l338 lab=r4n}
C {devices/lab_pin.sym} 2860 -1830 0 0 {name=l339 lab=d1}
C {devices/lab_pin.sym} 2860 -1770 0 0 {name=l340 lab=vb2}
C {devices/lab_pin.sym} 3000 -1830 0 0 {name=l341 lab=d1}
C {devices/lab_pin.sym} 3000 -1770 0 0 {name=l342 lab=vdd}
C {devices/lab_pin.sym} 3140 -1830 0 0 {name=l343 lab=d1}
C {devices/lab_pin.sym} 3140 -1770 0 0 {name=l344 lab=vref}
C {devices/lab_pin.sym} 3280 -1830 0 0 {name=l345 lab=d1}
C {devices/lab_pin.sym} 3280 -1770 0 0 {name=l346 lab=vss}
C {devices/lab_pin.sym} 3420 -1830 0 0 {name=l347 lab=d2}
C {devices/lab_pin.sym} 3420 -1770 0 0 {name=l348 lab=d3}
C {devices/lab_pin.sym} 3560 -1830 0 0 {name=l349 lab=d2}
C {devices/lab_pin.sym} 3560 -1770 0 0 {name=l350 lab=d4}
C {devices/lab_pin.sym} 3700 -1830 0 0 {name=l351 lab=d2}
C {devices/lab_pin.sym} 3700 -1770 0 0 {name=l352 lab=d5}
C {devices/lab_pin.sym} 3840 -1830 0 0 {name=l353 lab=d2}
C {devices/lab_pin.sym} 3840 -1770 0 0 {name=l354 lab=det}
C {devices/lab_pin.sym} 3980 -1830 0 0 {name=l355 lab=d2}
C {devices/lab_pin.sym} 3980 -1770 0 0 {name=l356 lab=iptat}
C {devices/lab_pin.sym} 4120 -1830 0 0 {name=l357 lab=d2}
C {devices/lab_pin.sym} 4120 -1770 0 0 {name=l358 lab=kick}
C {devices/lab_pin.sym} 4260 -1830 0 0 {name=l359 lab=d2}
C {devices/lab_pin.sym} 4260 -1770 0 0 {name=l360 lab=n1}
C {devices/lab_pin.sym} 200 -1670 0 0 {name=l361 lab=d2}
C {devices/lab_pin.sym} 200 -1610 0 0 {name=l362 lab=pbias}
C {devices/lab_pin.sym} 340 -1670 0 0 {name=l363 lab=d2}
C {devices/lab_pin.sym} 340 -1610 0 0 {name=l364 lab=pcasc}
C {devices/lab_pin.sym} 480 -1670 0 0 {name=l365 lab=d2}
C {devices/lab_pin.sym} 480 -1610 0 0 {name=l366 lab=r4}
C {devices/lab_pin.sym} 620 -1670 0 0 {name=l367 lab=d2}
C {devices/lab_pin.sym} 620 -1610 0 0 {name=l368 lab=r4n}
C {devices/lab_pin.sym} 760 -1670 0 0 {name=l369 lab=d2}
C {devices/lab_pin.sym} 760 -1610 0 0 {name=l370 lab=vb2}
C {devices/lab_pin.sym} 900 -1670 0 0 {name=l371 lab=d2}
C {devices/lab_pin.sym} 900 -1610 0 0 {name=l372 lab=vdd}
C {devices/lab_pin.sym} 1040 -1670 0 0 {name=l373 lab=d2}
C {devices/lab_pin.sym} 1040 -1610 0 0 {name=l374 lab=vss}
C {devices/lab_pin.sym} 1180 -1670 0 0 {name=l375 lab=d3}
C {devices/lab_pin.sym} 1180 -1610 0 0 {name=l376 lab=d4}
C {devices/lab_pin.sym} 1320 -1670 0 0 {name=l377 lab=d3}
C {devices/lab_pin.sym} 1320 -1610 0 0 {name=l378 lab=d5}
C {devices/lab_pin.sym} 1460 -1670 0 0 {name=l379 lab=d3}
C {devices/lab_pin.sym} 1460 -1610 0 0 {name=l380 lab=det}
C {devices/lab_pin.sym} 1600 -1670 0 0 {name=l381 lab=d3}
C {devices/lab_pin.sym} 1600 -1610 0 0 {name=l382 lab=iptat}
C {devices/lab_pin.sym} 1740 -1670 0 0 {name=l383 lab=d3}
C {devices/lab_pin.sym} 1740 -1610 0 0 {name=l384 lab=kick}
C {devices/lab_pin.sym} 1880 -1670 0 0 {name=l385 lab=d3}
C {devices/lab_pin.sym} 1880 -1610 0 0 {name=l386 lab=pbias}
C {devices/lab_pin.sym} 2020 -1670 0 0 {name=l387 lab=d3}
C {devices/lab_pin.sym} 2020 -1610 0 0 {name=l388 lab=pcasc}
C {devices/lab_pin.sym} 2160 -1670 0 0 {name=l389 lab=d3}
C {devices/lab_pin.sym} 2160 -1610 0 0 {name=l390 lab=r4}
C {devices/lab_pin.sym} 2300 -1670 0 0 {name=l391 lab=d3}
C {devices/lab_pin.sym} 2300 -1610 0 0 {name=l392 lab=r4n}
C {devices/lab_pin.sym} 2440 -1670 0 0 {name=l393 lab=d3}
C {devices/lab_pin.sym} 2440 -1610 0 0 {name=l394 lab=vb2}
C {devices/lab_pin.sym} 2580 -1670 0 0 {name=l395 lab=d3}
C {devices/lab_pin.sym} 2580 -1610 0 0 {name=l396 lab=vdd}
C {devices/lab_pin.sym} 2720 -1670 0 0 {name=l397 lab=d3}
C {devices/lab_pin.sym} 2720 -1610 0 0 {name=l398 lab=vref}
C {devices/lab_pin.sym} 2860 -1670 0 0 {name=l399 lab=d3}
C {devices/lab_pin.sym} 2860 -1610 0 0 {name=l400 lab=vss}
C {devices/lab_pin.sym} 3000 -1670 0 0 {name=l401 lab=d4}
C {devices/lab_pin.sym} 3000 -1610 0 0 {name=l402 lab=d5}
C {devices/lab_pin.sym} 3140 -1670 0 0 {name=l403 lab=d4}
C {devices/lab_pin.sym} 3140 -1610 0 0 {name=l404 lab=det}
C {devices/lab_pin.sym} 3280 -1670 0 0 {name=l405 lab=d4}
C {devices/lab_pin.sym} 3280 -1610 0 0 {name=l406 lab=iptat}
C {devices/lab_pin.sym} 3420 -1670 0 0 {name=l407 lab=d4}
C {devices/lab_pin.sym} 3420 -1610 0 0 {name=l408 lab=kick}
C {devices/lab_pin.sym} 3560 -1670 0 0 {name=l409 lab=d4}
C {devices/lab_pin.sym} 3560 -1610 0 0 {name=l410 lab=pbias}
C {devices/lab_pin.sym} 3700 -1670 0 0 {name=l411 lab=d4}
C {devices/lab_pin.sym} 3700 -1610 0 0 {name=l412 lab=pcasc}
C {devices/lab_pin.sym} 3840 -1670 0 0 {name=l413 lab=d4}
C {devices/lab_pin.sym} 3840 -1610 0 0 {name=l414 lab=r4}
C {devices/lab_pin.sym} 3980 -1670 0 0 {name=l415 lab=d4}
C {devices/lab_pin.sym} 3980 -1610 0 0 {name=l416 lab=r4n}
C {devices/lab_pin.sym} 4120 -1670 0 0 {name=l417 lab=d4}
C {devices/lab_pin.sym} 4120 -1610 0 0 {name=l418 lab=vb2}
C {devices/lab_pin.sym} 4260 -1670 0 0 {name=l419 lab=d4}
C {devices/lab_pin.sym} 4260 -1610 0 0 {name=l420 lab=vdd}
C {devices/lab_pin.sym} 200 -1510 0 0 {name=l421 lab=d4}
C {devices/lab_pin.sym} 200 -1450 0 0 {name=l422 lab=vss}
C {devices/lab_pin.sym} 340 -1510 0 0 {name=l423 lab=d5}
C {devices/lab_pin.sym} 340 -1450 0 0 {name=l424 lab=det}
C {devices/lab_pin.sym} 480 -1510 0 0 {name=l425 lab=d5}
C {devices/lab_pin.sym} 480 -1450 0 0 {name=l426 lab=iptat}
C {devices/lab_pin.sym} 620 -1510 0 0 {name=l427 lab=d5}
C {devices/lab_pin.sym} 620 -1450 0 0 {name=l428 lab=kick}
C {devices/lab_pin.sym} 760 -1510 0 0 {name=l429 lab=d5}
C {devices/lab_pin.sym} 760 -1450 0 0 {name=l430 lab=pbias}
C {devices/lab_pin.sym} 900 -1510 0 0 {name=l431 lab=d5}
C {devices/lab_pin.sym} 900 -1450 0 0 {name=l432 lab=pcasc}
C {devices/lab_pin.sym} 1040 -1510 0 0 {name=l433 lab=d5}
C {devices/lab_pin.sym} 1040 -1450 0 0 {name=l434 lab=r4}
C {devices/lab_pin.sym} 1180 -1510 0 0 {name=l435 lab=d5}
C {devices/lab_pin.sym} 1180 -1450 0 0 {name=l436 lab=r4n}
C {devices/lab_pin.sym} 1320 -1510 0 0 {name=l437 lab=d5}
C {devices/lab_pin.sym} 1320 -1450 0 0 {name=l438 lab=vb2}
C {devices/lab_pin.sym} 1460 -1510 0 0 {name=l439 lab=d5}
C {devices/lab_pin.sym} 1460 -1450 0 0 {name=l440 lab=vdd}
C {devices/lab_pin.sym} 1600 -1510 0 0 {name=l441 lab=d5}
C {devices/lab_pin.sym} 1600 -1450 0 0 {name=l442 lab=vss}
C {devices/lab_pin.sym} 1740 -1510 0 0 {name=l443 lab=det}
C {devices/lab_pin.sym} 1740 -1450 0 0 {name=l444 lab=dvbe}
C {devices/lab_pin.sym} 1880 -1510 0 0 {name=l445 lab=det}
C {devices/lab_pin.sym} 1880 -1450 0 0 {name=l446 lab=kick}
C {devices/lab_pin.sym} 2020 -1510 0 0 {name=l447 lab=det}
C {devices/lab_pin.sym} 2020 -1450 0 0 {name=l448 lab=n1}
C {devices/lab_pin.sym} 2160 -1510 0 0 {name=l449 lab=det}
C {devices/lab_pin.sym} 2160 -1450 0 0 {name=l450 lab=pbias}
C {devices/lab_pin.sym} 2300 -1510 0 0 {name=l451 lab=det}
C {devices/lab_pin.sym} 2300 -1450 0 0 {name=l452 lab=pcasc}
C {devices/lab_pin.sym} 2440 -1510 0 0 {name=l453 lab=det}
C {devices/lab_pin.sym} 2440 -1450 0 0 {name=l454 lab=r4}
C {devices/lab_pin.sym} 2580 -1510 0 0 {name=l455 lab=det}
C {devices/lab_pin.sym} 2580 -1450 0 0 {name=l456 lab=r4n}
C {devices/lab_pin.sym} 2720 -1510 0 0 {name=l457 lab=det}
C {devices/lab_pin.sym} 2720 -1450 0 0 {name=l458 lab=vb2}
C {devices/lab_pin.sym} 2860 -1510 0 0 {name=l459 lab=det}
C {devices/lab_pin.sym} 2860 -1450 0 0 {name=l460 lab=vbe}
C {devices/lab_pin.sym} 3000 -1510 0 0 {name=l461 lab=det}
C {devices/lab_pin.sym} 3000 -1450 0 0 {name=l462 lab=vbe3}
C {devices/lab_pin.sym} 3140 -1510 0 0 {name=l463 lab=det}
C {devices/lab_pin.sym} 3140 -1450 0 0 {name=l464 lab=vdd}
C {devices/lab_pin.sym} 3280 -1510 0 0 {name=l465 lab=det}
C {devices/lab_pin.sym} 3280 -1450 0 0 {name=l466 lab=vss}
C {devices/lab_pin.sym} 3420 -1510 0 0 {name=l467 lab=dvbe}
C {devices/lab_pin.sym} 3420 -1450 0 0 {name=l468 lab=iptat}
C {devices/lab_pin.sym} 3560 -1510 0 0 {name=l469 lab=dvbe}
C {devices/lab_pin.sym} 3560 -1450 0 0 {name=l470 lab=kick}
C {devices/lab_pin.sym} 3700 -1510 0 0 {name=l471 lab=dvbe}
C {devices/lab_pin.sym} 3700 -1450 0 0 {name=l472 lab=n1}
C {devices/lab_pin.sym} 3840 -1510 0 0 {name=l473 lab=dvbe}
C {devices/lab_pin.sym} 3840 -1450 0 0 {name=l474 lab=pbias}
C {devices/lab_pin.sym} 3980 -1510 0 0 {name=l475 lab=dvbe}
C {devices/lab_pin.sym} 3980 -1450 0 0 {name=l476 lab=pcasc}
C {devices/lab_pin.sym} 4120 -1510 0 0 {name=l477 lab=dvbe}
C {devices/lab_pin.sym} 4120 -1450 0 0 {name=l478 lab=vb2}
C {devices/lab_pin.sym} 4260 -1510 0 0 {name=l479 lab=dvbe}
C {devices/lab_pin.sym} 4260 -1450 0 0 {name=l480 lab=vbe}
C {devices/lab_pin.sym} 200 -1350 0 0 {name=l481 lab=dvbe}
C {devices/lab_pin.sym} 200 -1290 0 0 {name=l482 lab=vbe3}
C {devices/lab_pin.sym} 340 -1350 0 0 {name=l483 lab=dvbe}
C {devices/lab_pin.sym} 340 -1290 0 0 {name=l484 lab=vd1}
C {devices/lab_pin.sym} 480 -1350 0 0 {name=l485 lab=dvbe}
C {devices/lab_pin.sym} 480 -1290 0 0 {name=l486 lab=vd2}
C {devices/lab_pin.sym} 620 -1350 0 0 {name=l487 lab=dvbe}
C {devices/lab_pin.sym} 620 -1290 0 0 {name=l488 lab=vref}
C {devices/lab_pin.sym} 760 -1350 0 0 {name=l489 lab=dvbe}
C {devices/lab_pin.sym} 760 -1290 0 0 {name=l490 lab=vss}
C {devices/lab_pin.sym} 900 -1350 0 0 {name=l491 lab=iptat}
C {devices/lab_pin.sym} 900 -1290 0 0 {name=l492 lab=n1}
C {devices/lab_pin.sym} 1040 -1350 0 0 {name=l493 lab=iptat}
C {devices/lab_pin.sym} 1040 -1290 0 0 {name=l494 lab=pbias}
C {devices/lab_pin.sym} 1180 -1350 0 0 {name=l495 lab=iptat}
C {devices/lab_pin.sym} 1180 -1290 0 0 {name=l496 lab=pcasc}
C {devices/lab_pin.sym} 1320 -1350 0 0 {name=l497 lab=iptat}
C {devices/lab_pin.sym} 1320 -1290 0 0 {name=l498 lab=vb2}
C {devices/lab_pin.sym} 1460 -1350 0 0 {name=l499 lab=iptat}
C {devices/lab_pin.sym} 1460 -1290 0 0 {name=l500 lab=vbe}
C {devices/lab_pin.sym} 1600 -1350 0 0 {name=l501 lab=iptat}
C {devices/lab_pin.sym} 1600 -1290 0 0 {name=l502 lab=vref}
C {devices/lab_pin.sym} 1740 -1350 0 0 {name=l503 lab=iptat}
C {devices/lab_pin.sym} 1740 -1290 0 0 {name=l504 lab=vss}
C {devices/lab_pin.sym} 1880 -1350 0 0 {name=l505 lab=kick}
C {devices/lab_pin.sym} 1880 -1290 0 0 {name=l506 lab=pbias}
C {devices/lab_pin.sym} 2020 -1350 0 0 {name=l507 lab=kick}
C {devices/lab_pin.sym} 2020 -1290 0 0 {name=l508 lab=pcasc}
C {devices/lab_pin.sym} 2160 -1350 0 0 {name=l509 lab=kick}
C {devices/lab_pin.sym} 2160 -1290 0 0 {name=l510 lab=r4}
C {devices/lab_pin.sym} 2300 -1350 0 0 {name=l511 lab=kick}
C {devices/lab_pin.sym} 2300 -1290 0 0 {name=l512 lab=r4n}
C {devices/lab_pin.sym} 2440 -1350 0 0 {name=l513 lab=kick}
C {devices/lab_pin.sym} 2440 -1290 0 0 {name=l514 lab=vb2}
C {devices/lab_pin.sym} 2580 -1350 0 0 {name=l515 lab=kick}
C {devices/lab_pin.sym} 2580 -1290 0 0 {name=l516 lab=vbe}
C {devices/lab_pin.sym} 2720 -1350 0 0 {name=l517 lab=kick}
C {devices/lab_pin.sym} 2720 -1290 0 0 {name=l518 lab=vdd}
C {devices/lab_pin.sym} 2860 -1350 0 0 {name=l519 lab=kick}
C {devices/lab_pin.sym} 2860 -1290 0 0 {name=l520 lab=vss}
C {devices/lab_pin.sym} 3000 -1350 0 0 {name=l521 lab=n1}
C {devices/lab_pin.sym} 3000 -1290 0 0 {name=l522 lab=pbias}
C {devices/lab_pin.sym} 3140 -1350 0 0 {name=l523 lab=n1}
C {devices/lab_pin.sym} 3140 -1290 0 0 {name=l524 lab=pcasc}
C {devices/lab_pin.sym} 3280 -1350 0 0 {name=l525 lab=n1}
C {devices/lab_pin.sym} 3280 -1290 0 0 {name=l526 lab=vb2}
C {devices/lab_pin.sym} 3420 -1350 0 0 {name=l527 lab=n1}
C {devices/lab_pin.sym} 3420 -1290 0 0 {name=l528 lab=vbe}
C {devices/lab_pin.sym} 3560 -1350 0 0 {name=l529 lab=n1}
C {devices/lab_pin.sym} 3560 -1290 0 0 {name=l530 lab=vref}
C {devices/lab_pin.sym} 3700 -1350 0 0 {name=l531 lab=n1}
C {devices/lab_pin.sym} 3700 -1290 0 0 {name=l532 lab=vss}
C {devices/lab_pin.sym} 3840 -1350 0 0 {name=l533 lab=pbias}
C {devices/lab_pin.sym} 3840 -1290 0 0 {name=l534 lab=pcasc}
C {devices/lab_pin.sym} 3980 -1350 0 0 {name=l535 lab=pbias}
C {devices/lab_pin.sym} 3980 -1290 0 0 {name=l536 lab=r4}
C {devices/lab_pin.sym} 4120 -1350 0 0 {name=l537 lab=pbias}
C {devices/lab_pin.sym} 4120 -1290 0 0 {name=l538 lab=r4n}
C {devices/lab_pin.sym} 4260 -1350 0 0 {name=l539 lab=pbias}
C {devices/lab_pin.sym} 4260 -1290 0 0 {name=l540 lab=vb2}
C {devices/lab_pin.sym} 200 -1190 0 0 {name=l541 lab=pbias}
C {devices/lab_pin.sym} 200 -1130 0 0 {name=l542 lab=vbe}
C {devices/lab_pin.sym} 340 -1190 0 0 {name=l543 lab=pbias}
C {devices/lab_pin.sym} 340 -1130 0 0 {name=l544 lab=vbe3}
C {devices/lab_pin.sym} 480 -1190 0 0 {name=l545 lab=pbias}
C {devices/lab_pin.sym} 480 -1130 0 0 {name=l546 lab=vd1}
C {devices/lab_pin.sym} 620 -1190 0 0 {name=l547 lab=pbias}
C {devices/lab_pin.sym} 620 -1130 0 0 {name=l548 lab=vd2}
C {devices/lab_pin.sym} 760 -1190 0 0 {name=l549 lab=pbias}
C {devices/lab_pin.sym} 760 -1130 0 0 {name=l550 lab=vdd}
C {devices/lab_pin.sym} 900 -1190 0 0 {name=l551 lab=pbias}
C {devices/lab_pin.sym} 900 -1130 0 0 {name=l552 lab=vref}
C {devices/lab_pin.sym} 1040 -1190 0 0 {name=l553 lab=pbias}
C {devices/lab_pin.sym} 1040 -1130 0 0 {name=l554 lab=vss}
C {devices/lab_pin.sym} 1180 -1190 0 0 {name=l555 lab=pcasc}
C {devices/lab_pin.sym} 1180 -1130 0 0 {name=l556 lab=r4}
C {devices/lab_pin.sym} 1320 -1190 0 0 {name=l557 lab=pcasc}
C {devices/lab_pin.sym} 1320 -1130 0 0 {name=l558 lab=r4n}
C {devices/lab_pin.sym} 1460 -1190 0 0 {name=l559 lab=pcasc}
C {devices/lab_pin.sym} 1460 -1130 0 0 {name=l560 lab=vb2}
C {devices/lab_pin.sym} 1600 -1190 0 0 {name=l561 lab=pcasc}
C {devices/lab_pin.sym} 1600 -1130 0 0 {name=l562 lab=vbe}
C {devices/lab_pin.sym} 1740 -1190 0 0 {name=l563 lab=pcasc}
C {devices/lab_pin.sym} 1740 -1130 0 0 {name=l564 lab=vbe3}
C {devices/lab_pin.sym} 1880 -1190 0 0 {name=l565 lab=pcasc}
C {devices/lab_pin.sym} 1880 -1130 0 0 {name=l566 lab=vref}
C {devices/lab_pin.sym} 2020 -1190 0 0 {name=l567 lab=pcasc}
C {devices/lab_pin.sym} 2020 -1130 0 0 {name=l568 lab=vss}
C {devices/lab_pin.sym} 2160 -1190 0 0 {name=l569 lab=r4}
C {devices/lab_pin.sym} 2160 -1130 0 0 {name=l570 lab=r4n}
C {devices/lab_pin.sym} 2300 -1190 0 0 {name=l571 lab=r4}
C {devices/lab_pin.sym} 2300 -1130 0 0 {name=l572 lab=vbe}
C {devices/lab_pin.sym} 2440 -1190 0 0 {name=l573 lab=r4}
C {devices/lab_pin.sym} 2440 -1130 0 0 {name=l574 lab=vdd}
C {devices/lab_pin.sym} 2580 -1190 0 0 {name=l575 lab=r4}
C {devices/lab_pin.sym} 2580 -1130 0 0 {name=l576 lab=vss}
C {devices/lab_pin.sym} 2720 -1190 0 0 {name=l577 lab=r4n}
C {devices/lab_pin.sym} 2720 -1130 0 0 {name=l578 lab=vbe}
C {devices/lab_pin.sym} 2860 -1190 0 0 {name=l579 lab=r4n}
C {devices/lab_pin.sym} 2860 -1130 0 0 {name=l580 lab=vdd}
C {devices/lab_pin.sym} 3000 -1190 0 0 {name=l581 lab=r4n}
C {devices/lab_pin.sym} 3000 -1130 0 0 {name=l582 lab=vss}
C {devices/lab_pin.sym} 3140 -1190 0 0 {name=l583 lab=vb2}
C {devices/lab_pin.sym} 3140 -1130 0 0 {name=l584 lab=vbe}
C {devices/lab_pin.sym} 3280 -1190 0 0 {name=l585 lab=vb2}
C {devices/lab_pin.sym} 3280 -1130 0 0 {name=l586 lab=vref}
C {devices/lab_pin.sym} 3420 -1190 0 0 {name=l587 lab=vb2}
C {devices/lab_pin.sym} 3420 -1130 0 0 {name=l588 lab=vss}
C {devices/lab_pin.sym} 3560 -1190 0 0 {name=l589 lab=vbe}
C {devices/lab_pin.sym} 3560 -1130 0 0 {name=l590 lab=vbe3}
C {devices/lab_pin.sym} 3700 -1190 0 0 {name=l591 lab=vbe}
C {devices/lab_pin.sym} 3700 -1130 0 0 {name=l592 lab=vd1}
C {devices/lab_pin.sym} 3840 -1190 0 0 {name=l593 lab=vbe}
C {devices/lab_pin.sym} 3840 -1130 0 0 {name=l594 lab=vd2}
C {devices/lab_pin.sym} 3980 -1190 0 0 {name=l595 lab=vbe}
C {devices/lab_pin.sym} 3980 -1130 0 0 {name=l596 lab=vref}
C {devices/lab_pin.sym} 4120 -1190 0 0 {name=l597 lab=vbe}
C {devices/lab_pin.sym} 4120 -1130 0 0 {name=l598 lab=vss}
C {devices/lab_pin.sym} 4260 -1190 0 0 {name=l599 lab=vbe3}
C {devices/lab_pin.sym} 4260 -1130 0 0 {name=l600 lab=vd1}
C {devices/lab_pin.sym} 200 -1030 0 0 {name=l601 lab=vbe3}
C {devices/lab_pin.sym} 200 -970 0 0 {name=l602 lab=vd2}
C {devices/lab_pin.sym} 340 -1030 0 0 {name=l603 lab=vbe3}
C {devices/lab_pin.sym} 340 -970 0 0 {name=l604 lab=vss}
C {devices/lab_pin.sym} 480 -1030 0 0 {name=l605 lab=vd1}
C {devices/lab_pin.sym} 480 -970 0 0 {name=l606 lab=vd2}
C {devices/lab_pin.sym} 620 -1030 0 0 {name=l607 lab=vd1}
C {devices/lab_pin.sym} 620 -970 0 0 {name=l608 lab=vss}
C {devices/lab_pin.sym} 760 -1030 0 0 {name=l609 lab=vd2}
C {devices/lab_pin.sym} 760 -970 0 0 {name=l610 lab=vss}
C {devices/lab_pin.sym} 900 -1030 0 0 {name=l611 lab=vref}
C {devices/lab_pin.sym} 900 -970 0 0 {name=l612 lab=vss}
C {devices/lab_pin.sym} 1040 -1030 0 0 {name=l613 lab=vss}
C {devices/lab_pin.sym} 1040 -970 0 0 {name=l614 lab=b1b}
C {devices/lab_pin.sym} 1180 -1030 0 0 {name=l615 lab=vss}
C {devices/lab_pin.sym} 1180 -970 0 0 {name=l616 lab=c2}
C {devices/lab_pin.sym} 1320 -1030 0 0 {name=l617 lab=vss}
C {devices/lab_pin.sym} 1320 -970 0 0 {name=l618 lab=d1}
C {devices/lab_pin.sym} 1460 -1030 0 0 {name=l619 lab=vss}
C {devices/lab_pin.sym} 1460 -970 0 0 {name=l620 lab=d2}
C {devices/lab_pin.sym} 1600 -1030 0 0 {name=l621 lab=vss}
C {devices/lab_pin.sym} 1600 -970 0 0 {name=l622 lab=d3}
C {devices/lab_pin.sym} 1740 -1030 0 0 {name=l623 lab=vss}
C {devices/lab_pin.sym} 1740 -970 0 0 {name=l624 lab=d4}
C {devices/lab_pin.sym} 1880 -1030 0 0 {name=l625 lab=vss}
C {devices/lab_pin.sym} 1880 -970 0 0 {name=l626 lab=d5}
C {devices/lab_pin.sym} 2020 -1030 0 0 {name=l627 lab=vss}
C {devices/lab_pin.sym} 2020 -970 0 0 {name=l628 lab=det}
C {devices/lab_pin.sym} 2160 -1030 0 0 {name=l629 lab=vss}
C {devices/lab_pin.sym} 2160 -970 0 0 {name=l630 lab=dvbe}
C {devices/lab_pin.sym} 2300 -1030 0 0 {name=l631 lab=vss}
C {devices/lab_pin.sym} 2300 -970 0 0 {name=l632 lab=iptat}
C {devices/lab_pin.sym} 2440 -1030 0 0 {name=l633 lab=vss}
C {devices/lab_pin.sym} 2440 -970 0 0 {name=l634 lab=kick}
C {devices/lab_pin.sym} 2580 -1030 0 0 {name=l635 lab=vss}
C {devices/lab_pin.sym} 2580 -970 0 0 {name=l636 lab=n1}
C {devices/lab_pin.sym} 2720 -1030 0 0 {name=l637 lab=vss}
C {devices/lab_pin.sym} 2720 -970 0 0 {name=l638 lab=pbias}
C {devices/lab_pin.sym} 2860 -1030 0 0 {name=l639 lab=vss}
C {devices/lab_pin.sym} 2860 -970 0 0 {name=l640 lab=pcasc}
C {devices/lab_pin.sym} 3000 -1030 0 0 {name=l641 lab=vss}
C {devices/lab_pin.sym} 3000 -970 0 0 {name=l642 lab=r4}
C {devices/lab_pin.sym} 3140 -1030 0 0 {name=l643 lab=vss}
C {devices/lab_pin.sym} 3140 -970 0 0 {name=l644 lab=r4n}
C {devices/lab_pin.sym} 3280 -1030 0 0 {name=l645 lab=vss}
C {devices/lab_pin.sym} 3280 -970 0 0 {name=l646 lab=vb2}
C {devices/lab_pin.sym} 3420 -1030 0 0 {name=l647 lab=vss}
C {devices/lab_pin.sym} 3420 -970 0 0 {name=l648 lab=vbe}
C {devices/lab_pin.sym} 3560 -1030 0 0 {name=l649 lab=vss}
C {devices/lab_pin.sym} 3560 -970 0 0 {name=l650 lab=vbe3}
C {devices/lab_pin.sym} 3700 -1030 0 0 {name=l651 lab=vss}
C {devices/lab_pin.sym} 3700 -970 0 0 {name=l652 lab=vd1}
C {devices/lab_pin.sym} 3840 -1030 0 0 {name=l653 lab=vss}
C {devices/lab_pin.sym} 3840 -970 0 0 {name=l654 lab=vd2}
C {devices/lab_pin.sym} 3980 -1030 0 0 {name=l655 lab=vss}
C {devices/lab_pin.sym} 3980 -970 0 0 {name=l656 lab=vdd}
C {devices/lab_pin.sym} 4120 -1030 0 0 {name=l657 lab=vss}
C {devices/lab_pin.sym} 4120 -970 0 0 {name=l658 lab=vref}
